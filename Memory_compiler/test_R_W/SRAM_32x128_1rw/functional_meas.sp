.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_8ck110 FIND v(dout1_8) AT=60.025n

.meas tran vdout1_9ck110 FIND v(dout1_9) AT=60.025n

.meas tran vdout1_10ck110 FIND v(dout1_10) AT=60.025n

.meas tran vdout1_11ck110 FIND v(dout1_11) AT=60.025n

.meas tran vdout1_12ck110 FIND v(dout1_12) AT=60.025n

.meas tran vdout1_13ck110 FIND v(dout1_13) AT=60.025n

.meas tran vdout1_14ck110 FIND v(dout1_14) AT=60.025n

.meas tran vdout1_15ck110 FIND v(dout1_15) AT=60.025n

.meas tran vdout1_16ck110 FIND v(dout1_16) AT=60.025n

.meas tran vdout1_17ck110 FIND v(dout1_17) AT=60.025n

.meas tran vdout1_18ck110 FIND v(dout1_18) AT=60.025n

.meas tran vdout1_19ck110 FIND v(dout1_19) AT=60.025n

.meas tran vdout1_20ck110 FIND v(dout1_20) AT=60.025n

.meas tran vdout1_21ck110 FIND v(dout1_21) AT=60.025n

.meas tran vdout1_22ck110 FIND v(dout1_22) AT=60.025n

.meas tran vdout1_23ck110 FIND v(dout1_23) AT=60.025n

.meas tran vdout1_24ck110 FIND v(dout1_24) AT=60.025n

.meas tran vdout1_25ck110 FIND v(dout1_25) AT=60.025n

.meas tran vdout1_26ck110 FIND v(dout1_26) AT=60.025n

.meas tran vdout1_27ck110 FIND v(dout1_27) AT=60.025n

.meas tran vdout1_28ck110 FIND v(dout1_28) AT=60.025n

.meas tran vdout1_29ck110 FIND v(dout1_29) AT=60.025n

.meas tran vdout1_30ck110 FIND v(dout1_30) AT=60.025n

.meas tran vdout1_31ck110 FIND v(dout1_31) AT=60.025n

.meas tran vdout1_0ck120 FIND v(dout1_0) AT=65.025n

.meas tran vdout1_1ck120 FIND v(dout1_1) AT=65.025n

.meas tran vdout1_2ck120 FIND v(dout1_2) AT=65.025n

.meas tran vdout1_3ck120 FIND v(dout1_3) AT=65.025n

.meas tran vdout1_4ck120 FIND v(dout1_4) AT=65.025n

.meas tran vdout1_5ck120 FIND v(dout1_5) AT=65.025n

.meas tran vdout1_6ck120 FIND v(dout1_6) AT=65.025n

.meas tran vdout1_7ck120 FIND v(dout1_7) AT=65.025n

.meas tran vdout1_8ck120 FIND v(dout1_8) AT=65.025n

.meas tran vdout1_9ck120 FIND v(dout1_9) AT=65.025n

.meas tran vdout1_10ck120 FIND v(dout1_10) AT=65.025n

.meas tran vdout1_11ck120 FIND v(dout1_11) AT=65.025n

.meas tran vdout1_12ck120 FIND v(dout1_12) AT=65.025n

.meas tran vdout1_13ck120 FIND v(dout1_13) AT=65.025n

.meas tran vdout1_14ck120 FIND v(dout1_14) AT=65.025n

.meas tran vdout1_15ck120 FIND v(dout1_15) AT=65.025n

.meas tran vdout1_16ck120 FIND v(dout1_16) AT=65.025n

.meas tran vdout1_17ck120 FIND v(dout1_17) AT=65.025n

.meas tran vdout1_18ck120 FIND v(dout1_18) AT=65.025n

.meas tran vdout1_19ck120 FIND v(dout1_19) AT=65.025n

.meas tran vdout1_20ck120 FIND v(dout1_20) AT=65.025n

.meas tran vdout1_21ck120 FIND v(dout1_21) AT=65.025n

.meas tran vdout1_22ck120 FIND v(dout1_22) AT=65.025n

.meas tran vdout1_23ck120 FIND v(dout1_23) AT=65.025n

.meas tran vdout1_24ck120 FIND v(dout1_24) AT=65.025n

.meas tran vdout1_25ck120 FIND v(dout1_25) AT=65.025n

.meas tran vdout1_26ck120 FIND v(dout1_26) AT=65.025n

.meas tran vdout1_27ck120 FIND v(dout1_27) AT=65.025n

.meas tran vdout1_28ck120 FIND v(dout1_28) AT=65.025n

.meas tran vdout1_29ck120 FIND v(dout1_29) AT=65.025n

.meas tran vdout1_30ck120 FIND v(dout1_30) AT=65.025n

.meas tran vdout1_31ck120 FIND v(dout1_31) AT=65.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_19ck150 FIND v(dout1_19) AT=80.025n

.meas tran vdout1_20ck150 FIND v(dout1_20) AT=80.025n

.meas tran vdout1_21ck150 FIND v(dout1_21) AT=80.025n

.meas tran vdout1_22ck150 FIND v(dout1_22) AT=80.025n

.meas tran vdout1_23ck150 FIND v(dout1_23) AT=80.025n

.meas tran vdout1_24ck150 FIND v(dout1_24) AT=80.025n

.meas tran vdout1_25ck150 FIND v(dout1_25) AT=80.025n

.meas tran vdout1_26ck150 FIND v(dout1_26) AT=80.025n

.meas tran vdout1_27ck150 FIND v(dout1_27) AT=80.025n

.meas tran vdout1_28ck150 FIND v(dout1_28) AT=80.025n

.meas tran vdout1_29ck150 FIND v(dout1_29) AT=80.025n

.meas tran vdout1_30ck150 FIND v(dout1_30) AT=80.025n

.meas tran vdout1_31ck150 FIND v(dout1_31) AT=80.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_17ck180 FIND v(dout1_17) AT=95.025n

.meas tran vdout1_18ck180 FIND v(dout1_18) AT=95.025n

.meas tran vdout1_19ck180 FIND v(dout1_19) AT=95.025n

.meas tran vdout1_20ck180 FIND v(dout1_20) AT=95.025n

.meas tran vdout1_21ck180 FIND v(dout1_21) AT=95.025n

.meas tran vdout1_22ck180 FIND v(dout1_22) AT=95.025n

.meas tran vdout1_23ck180 FIND v(dout1_23) AT=95.025n

.meas tran vdout1_24ck180 FIND v(dout1_24) AT=95.025n

.meas tran vdout1_25ck180 FIND v(dout1_25) AT=95.025n

.meas tran vdout1_26ck180 FIND v(dout1_26) AT=95.025n

.meas tran vdout1_27ck180 FIND v(dout1_27) AT=95.025n

.meas tran vdout1_28ck180 FIND v(dout1_28) AT=95.025n

.meas tran vdout1_29ck180 FIND v(dout1_29) AT=95.025n

.meas tran vdout1_30ck180 FIND v(dout1_30) AT=95.025n

.meas tran vdout1_31ck180 FIND v(dout1_31) AT=95.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_16ck200 FIND v(dout1_16) AT=105.025n

.meas tran vdout1_17ck200 FIND v(dout1_17) AT=105.025n

.meas tran vdout1_18ck200 FIND v(dout1_18) AT=105.025n

.meas tran vdout1_19ck200 FIND v(dout1_19) AT=105.025n

.meas tran vdout1_20ck200 FIND v(dout1_20) AT=105.025n

.meas tran vdout1_21ck200 FIND v(dout1_21) AT=105.025n

.meas tran vdout1_22ck200 FIND v(dout1_22) AT=105.025n

.meas tran vdout1_23ck200 FIND v(dout1_23) AT=105.025n

.meas tran vdout1_24ck200 FIND v(dout1_24) AT=105.025n

.meas tran vdout1_25ck200 FIND v(dout1_25) AT=105.025n

.meas tran vdout1_26ck200 FIND v(dout1_26) AT=105.025n

.meas tran vdout1_27ck200 FIND v(dout1_27) AT=105.025n

.meas tran vdout1_28ck200 FIND v(dout1_28) AT=105.025n

.meas tran vdout1_29ck200 FIND v(dout1_29) AT=105.025n

.meas tran vdout1_30ck200 FIND v(dout1_30) AT=105.025n

.meas tran vdout1_31ck200 FIND v(dout1_31) AT=105.025n

.meas tran vdout1_0ck210 FIND v(dout1_0) AT=110.025n

.meas tran vdout1_1ck210 FIND v(dout1_1) AT=110.025n

.meas tran vdout1_2ck210 FIND v(dout1_2) AT=110.025n

.meas tran vdout1_3ck210 FIND v(dout1_3) AT=110.025n

.meas tran vdout1_4ck210 FIND v(dout1_4) AT=110.025n

.meas tran vdout1_5ck210 FIND v(dout1_5) AT=110.025n

.meas tran vdout1_6ck210 FIND v(dout1_6) AT=110.025n

.meas tran vdout1_7ck210 FIND v(dout1_7) AT=110.025n

.meas tran vdout1_8ck210 FIND v(dout1_8) AT=110.025n

.meas tran vdout1_9ck210 FIND v(dout1_9) AT=110.025n

.meas tran vdout1_10ck210 FIND v(dout1_10) AT=110.025n

.meas tran vdout1_11ck210 FIND v(dout1_11) AT=110.025n

.meas tran vdout1_12ck210 FIND v(dout1_12) AT=110.025n

.meas tran vdout1_13ck210 FIND v(dout1_13) AT=110.025n

.meas tran vdout1_14ck210 FIND v(dout1_14) AT=110.025n

.meas tran vdout1_15ck210 FIND v(dout1_15) AT=110.025n

.meas tran vdout1_16ck210 FIND v(dout1_16) AT=110.025n

.meas tran vdout1_17ck210 FIND v(dout1_17) AT=110.025n

.meas tran vdout1_18ck210 FIND v(dout1_18) AT=110.025n

.meas tran vdout1_19ck210 FIND v(dout1_19) AT=110.025n

.meas tran vdout1_20ck210 FIND v(dout1_20) AT=110.025n

.meas tran vdout1_21ck210 FIND v(dout1_21) AT=110.025n

.meas tran vdout1_22ck210 FIND v(dout1_22) AT=110.025n

.meas tran vdout1_23ck210 FIND v(dout1_23) AT=110.025n

.meas tran vdout1_24ck210 FIND v(dout1_24) AT=110.025n

.meas tran vdout1_25ck210 FIND v(dout1_25) AT=110.025n

.meas tran vdout1_26ck210 FIND v(dout1_26) AT=110.025n

.meas tran vdout1_27ck210 FIND v(dout1_27) AT=110.025n

.meas tran vdout1_28ck210 FIND v(dout1_28) AT=110.025n

.meas tran vdout1_29ck210 FIND v(dout1_29) AT=110.025n

.meas tran vdout1_30ck210 FIND v(dout1_30) AT=110.025n

.meas tran vdout1_31ck210 FIND v(dout1_31) AT=110.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_0ck270 FIND v(dout1_0) AT=140.025n

.meas tran vdout1_1ck270 FIND v(dout1_1) AT=140.025n

.meas tran vdout1_2ck270 FIND v(dout1_2) AT=140.025n

.meas tran vdout1_3ck270 FIND v(dout1_3) AT=140.025n

.meas tran vdout1_4ck270 FIND v(dout1_4) AT=140.025n

.meas tran vdout1_5ck270 FIND v(dout1_5) AT=140.025n

.meas tran vdout1_6ck270 FIND v(dout1_6) AT=140.025n

.meas tran vdout1_7ck270 FIND v(dout1_7) AT=140.025n

.meas tran vdout1_8ck270 FIND v(dout1_8) AT=140.025n

.meas tran vdout1_9ck270 FIND v(dout1_9) AT=140.025n

.meas tran vdout1_10ck270 FIND v(dout1_10) AT=140.025n

.meas tran vdout1_11ck270 FIND v(dout1_11) AT=140.025n

.meas tran vdout1_12ck270 FIND v(dout1_12) AT=140.025n

.meas tran vdout1_13ck270 FIND v(dout1_13) AT=140.025n

.meas tran vdout1_14ck270 FIND v(dout1_14) AT=140.025n

.meas tran vdout1_15ck270 FIND v(dout1_15) AT=140.025n

.meas tran vdout1_16ck270 FIND v(dout1_16) AT=140.025n

.meas tran vdout1_17ck270 FIND v(dout1_17) AT=140.025n

.meas tran vdout1_18ck270 FIND v(dout1_18) AT=140.025n

.meas tran vdout1_19ck270 FIND v(dout1_19) AT=140.025n

.meas tran vdout1_20ck270 FIND v(dout1_20) AT=140.025n

.meas tran vdout1_21ck270 FIND v(dout1_21) AT=140.025n

.meas tran vdout1_22ck270 FIND v(dout1_22) AT=140.025n

.meas tran vdout1_23ck270 FIND v(dout1_23) AT=140.025n

.meas tran vdout1_24ck270 FIND v(dout1_24) AT=140.025n

.meas tran vdout1_25ck270 FIND v(dout1_25) AT=140.025n

.meas tran vdout1_26ck270 FIND v(dout1_26) AT=140.025n

.meas tran vdout1_27ck270 FIND v(dout1_27) AT=140.025n

.meas tran vdout1_28ck270 FIND v(dout1_28) AT=140.025n

.meas tran vdout1_29ck270 FIND v(dout1_29) AT=140.025n

.meas tran vdout1_30ck270 FIND v(dout1_30) AT=140.025n

.meas tran vdout1_31ck270 FIND v(dout1_31) AT=140.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_8ck340 FIND v(dout1_8) AT=175.025n

.meas tran vdout1_9ck340 FIND v(dout1_9) AT=175.025n

.meas tran vdout1_10ck340 FIND v(dout1_10) AT=175.025n

.meas tran vdout1_11ck340 FIND v(dout1_11) AT=175.025n

.meas tran vdout1_12ck340 FIND v(dout1_12) AT=175.025n

.meas tran vdout1_13ck340 FIND v(dout1_13) AT=175.025n

.meas tran vdout1_14ck340 FIND v(dout1_14) AT=175.025n

.meas tran vdout1_15ck340 FIND v(dout1_15) AT=175.025n

.meas tran vdout1_16ck340 FIND v(dout1_16) AT=175.025n

.meas tran vdout1_17ck340 FIND v(dout1_17) AT=175.025n

.meas tran vdout1_18ck340 FIND v(dout1_18) AT=175.025n

.meas tran vdout1_19ck340 FIND v(dout1_19) AT=175.025n

.meas tran vdout1_20ck340 FIND v(dout1_20) AT=175.025n

.meas tran vdout1_21ck340 FIND v(dout1_21) AT=175.025n

.meas tran vdout1_22ck340 FIND v(dout1_22) AT=175.025n

.meas tran vdout1_23ck340 FIND v(dout1_23) AT=175.025n

.meas tran vdout1_24ck340 FIND v(dout1_24) AT=175.025n

.meas tran vdout1_25ck340 FIND v(dout1_25) AT=175.025n

.meas tran vdout1_26ck340 FIND v(dout1_26) AT=175.025n

.meas tran vdout1_27ck340 FIND v(dout1_27) AT=175.025n

.meas tran vdout1_28ck340 FIND v(dout1_28) AT=175.025n

.meas tran vdout1_29ck340 FIND v(dout1_29) AT=175.025n

.meas tran vdout1_30ck340 FIND v(dout1_30) AT=175.025n

.meas tran vdout1_31ck340 FIND v(dout1_31) AT=175.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_22ck350 FIND v(dout1_22) AT=180.025n

.meas tran vdout1_23ck350 FIND v(dout1_23) AT=180.025n

.meas tran vdout1_24ck350 FIND v(dout1_24) AT=180.025n

.meas tran vdout1_25ck350 FIND v(dout1_25) AT=180.025n

.meas tran vdout1_26ck350 FIND v(dout1_26) AT=180.025n

.meas tran vdout1_27ck350 FIND v(dout1_27) AT=180.025n

.meas tran vdout1_28ck350 FIND v(dout1_28) AT=180.025n

.meas tran vdout1_29ck350 FIND v(dout1_29) AT=180.025n

.meas tran vdout1_30ck350 FIND v(dout1_30) AT=180.025n

.meas tran vdout1_31ck350 FIND v(dout1_31) AT=180.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_23ck360 FIND v(dout1_23) AT=185.025n

.meas tran vdout1_24ck360 FIND v(dout1_24) AT=185.025n

.meas tran vdout1_25ck360 FIND v(dout1_25) AT=185.025n

.meas tran vdout1_26ck360 FIND v(dout1_26) AT=185.025n

.meas tran vdout1_27ck360 FIND v(dout1_27) AT=185.025n

.meas tran vdout1_28ck360 FIND v(dout1_28) AT=185.025n

.meas tran vdout1_29ck360 FIND v(dout1_29) AT=185.025n

.meas tran vdout1_30ck360 FIND v(dout1_30) AT=185.025n

.meas tran vdout1_31ck360 FIND v(dout1_31) AT=185.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_23ck380 FIND v(dout1_23) AT=195.025n

.meas tran vdout1_24ck380 FIND v(dout1_24) AT=195.025n

.meas tran vdout1_25ck380 FIND v(dout1_25) AT=195.025n

.meas tran vdout1_26ck380 FIND v(dout1_26) AT=195.025n

.meas tran vdout1_27ck380 FIND v(dout1_27) AT=195.025n

.meas tran vdout1_28ck380 FIND v(dout1_28) AT=195.025n

.meas tran vdout1_29ck380 FIND v(dout1_29) AT=195.025n

.meas tran vdout1_30ck380 FIND v(dout1_30) AT=195.025n

.meas tran vdout1_31ck380 FIND v(dout1_31) AT=195.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_19ck420 FIND v(dout1_19) AT=215.025n

.meas tran vdout1_20ck420 FIND v(dout1_20) AT=215.025n

.meas tran vdout1_21ck420 FIND v(dout1_21) AT=215.025n

.meas tran vdout1_22ck420 FIND v(dout1_22) AT=215.025n

.meas tran vdout1_23ck420 FIND v(dout1_23) AT=215.025n

.meas tran vdout1_24ck420 FIND v(dout1_24) AT=215.025n

.meas tran vdout1_25ck420 FIND v(dout1_25) AT=215.025n

.meas tran vdout1_26ck420 FIND v(dout1_26) AT=215.025n

.meas tran vdout1_27ck420 FIND v(dout1_27) AT=215.025n

.meas tran vdout1_28ck420 FIND v(dout1_28) AT=215.025n

.meas tran vdout1_29ck420 FIND v(dout1_29) AT=215.025n

.meas tran vdout1_30ck420 FIND v(dout1_30) AT=215.025n

.meas tran vdout1_31ck420 FIND v(dout1_31) AT=215.025n

.meas tran vdout1_0ck430 FIND v(dout1_0) AT=220.025n

.meas tran vdout1_1ck430 FIND v(dout1_1) AT=220.025n

.meas tran vdout1_2ck430 FIND v(dout1_2) AT=220.025n

.meas tran vdout1_3ck430 FIND v(dout1_3) AT=220.025n

.meas tran vdout1_4ck430 FIND v(dout1_4) AT=220.025n

.meas tran vdout1_5ck430 FIND v(dout1_5) AT=220.025n

.meas tran vdout1_6ck430 FIND v(dout1_6) AT=220.025n

.meas tran vdout1_7ck430 FIND v(dout1_7) AT=220.025n

.meas tran vdout1_8ck430 FIND v(dout1_8) AT=220.025n

.meas tran vdout1_9ck430 FIND v(dout1_9) AT=220.025n

.meas tran vdout1_10ck430 FIND v(dout1_10) AT=220.025n

.meas tran vdout1_11ck430 FIND v(dout1_11) AT=220.025n

.meas tran vdout1_12ck430 FIND v(dout1_12) AT=220.025n

.meas tran vdout1_13ck430 FIND v(dout1_13) AT=220.025n

.meas tran vdout1_14ck430 FIND v(dout1_14) AT=220.025n

.meas tran vdout1_15ck430 FIND v(dout1_15) AT=220.025n

.meas tran vdout1_16ck430 FIND v(dout1_16) AT=220.025n

.meas tran vdout1_17ck430 FIND v(dout1_17) AT=220.025n

.meas tran vdout1_18ck430 FIND v(dout1_18) AT=220.025n

.meas tran vdout1_19ck430 FIND v(dout1_19) AT=220.025n

.meas tran vdout1_20ck430 FIND v(dout1_20) AT=220.025n

.meas tran vdout1_21ck430 FIND v(dout1_21) AT=220.025n

.meas tran vdout1_22ck430 FIND v(dout1_22) AT=220.025n

.meas tran vdout1_23ck430 FIND v(dout1_23) AT=220.025n

.meas tran vdout1_24ck430 FIND v(dout1_24) AT=220.025n

.meas tran vdout1_25ck430 FIND v(dout1_25) AT=220.025n

.meas tran vdout1_26ck430 FIND v(dout1_26) AT=220.025n

.meas tran vdout1_27ck430 FIND v(dout1_27) AT=220.025n

.meas tran vdout1_28ck430 FIND v(dout1_28) AT=220.025n

.meas tran vdout1_29ck430 FIND v(dout1_29) AT=220.025n

.meas tran vdout1_30ck430 FIND v(dout1_30) AT=220.025n

.meas tran vdout1_31ck430 FIND v(dout1_31) AT=220.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_19ck450 FIND v(dout1_19) AT=230.025n

.meas tran vdout1_20ck450 FIND v(dout1_20) AT=230.025n

.meas tran vdout1_21ck450 FIND v(dout1_21) AT=230.025n

.meas tran vdout1_22ck450 FIND v(dout1_22) AT=230.025n

.meas tran vdout1_23ck450 FIND v(dout1_23) AT=230.025n

.meas tran vdout1_24ck450 FIND v(dout1_24) AT=230.025n

.meas tran vdout1_25ck450 FIND v(dout1_25) AT=230.025n

.meas tran vdout1_26ck450 FIND v(dout1_26) AT=230.025n

.meas tran vdout1_27ck450 FIND v(dout1_27) AT=230.025n

.meas tran vdout1_28ck450 FIND v(dout1_28) AT=230.025n

.meas tran vdout1_29ck450 FIND v(dout1_29) AT=230.025n

.meas tran vdout1_30ck450 FIND v(dout1_30) AT=230.025n

.meas tran vdout1_31ck450 FIND v(dout1_31) AT=230.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_16ck460 FIND v(dout1_16) AT=235.025n

.meas tran vdout1_17ck460 FIND v(dout1_17) AT=235.025n

.meas tran vdout1_18ck460 FIND v(dout1_18) AT=235.025n

.meas tran vdout1_19ck460 FIND v(dout1_19) AT=235.025n

.meas tran vdout1_20ck460 FIND v(dout1_20) AT=235.025n

.meas tran vdout1_21ck460 FIND v(dout1_21) AT=235.025n

.meas tran vdout1_22ck460 FIND v(dout1_22) AT=235.025n

.meas tran vdout1_23ck460 FIND v(dout1_23) AT=235.025n

.meas tran vdout1_24ck460 FIND v(dout1_24) AT=235.025n

.meas tran vdout1_25ck460 FIND v(dout1_25) AT=235.025n

.meas tran vdout1_26ck460 FIND v(dout1_26) AT=235.025n

.meas tran vdout1_27ck460 FIND v(dout1_27) AT=235.025n

.meas tran vdout1_28ck460 FIND v(dout1_28) AT=235.025n

.meas tran vdout1_29ck460 FIND v(dout1_29) AT=235.025n

.meas tran vdout1_30ck460 FIND v(dout1_30) AT=235.025n

.meas tran vdout1_31ck460 FIND v(dout1_31) AT=235.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_22ck480 FIND v(dout1_22) AT=245.025n

.meas tran vdout1_23ck480 FIND v(dout1_23) AT=245.025n

.meas tran vdout1_24ck480 FIND v(dout1_24) AT=245.025n

.meas tran vdout1_25ck480 FIND v(dout1_25) AT=245.025n

.meas tran vdout1_26ck480 FIND v(dout1_26) AT=245.025n

.meas tran vdout1_27ck480 FIND v(dout1_27) AT=245.025n

.meas tran vdout1_28ck480 FIND v(dout1_28) AT=245.025n

.meas tran vdout1_29ck480 FIND v(dout1_29) AT=245.025n

.meas tran vdout1_30ck480 FIND v(dout1_30) AT=245.025n

.meas tran vdout1_31ck480 FIND v(dout1_31) AT=245.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_19ck490 FIND v(dout1_19) AT=250.025n

.meas tran vdout1_20ck490 FIND v(dout1_20) AT=250.025n

.meas tran vdout1_21ck490 FIND v(dout1_21) AT=250.025n

.meas tran vdout1_22ck490 FIND v(dout1_22) AT=250.025n

.meas tran vdout1_23ck490 FIND v(dout1_23) AT=250.025n

.meas tran vdout1_24ck490 FIND v(dout1_24) AT=250.025n

.meas tran vdout1_25ck490 FIND v(dout1_25) AT=250.025n

.meas tran vdout1_26ck490 FIND v(dout1_26) AT=250.025n

.meas tran vdout1_27ck490 FIND v(dout1_27) AT=250.025n

.meas tran vdout1_28ck490 FIND v(dout1_28) AT=250.025n

.meas tran vdout1_29ck490 FIND v(dout1_29) AT=250.025n

.meas tran vdout1_30ck490 FIND v(dout1_30) AT=250.025n

.meas tran vdout1_31ck490 FIND v(dout1_31) AT=250.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_22ck510 FIND v(dout1_22) AT=260.025n

.meas tran vdout1_23ck510 FIND v(dout1_23) AT=260.025n

.meas tran vdout1_24ck510 FIND v(dout1_24) AT=260.025n

.meas tran vdout1_25ck510 FIND v(dout1_25) AT=260.025n

.meas tran vdout1_26ck510 FIND v(dout1_26) AT=260.025n

.meas tran vdout1_27ck510 FIND v(dout1_27) AT=260.025n

.meas tran vdout1_28ck510 FIND v(dout1_28) AT=260.025n

.meas tran vdout1_29ck510 FIND v(dout1_29) AT=260.025n

.meas tran vdout1_30ck510 FIND v(dout1_30) AT=260.025n

.meas tran vdout1_31ck510 FIND v(dout1_31) AT=260.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_22ck530 FIND v(dout1_22) AT=270.025n

.meas tran vdout1_23ck530 FIND v(dout1_23) AT=270.025n

.meas tran vdout1_24ck530 FIND v(dout1_24) AT=270.025n

.meas tran vdout1_25ck530 FIND v(dout1_25) AT=270.025n

.meas tran vdout1_26ck530 FIND v(dout1_26) AT=270.025n

.meas tran vdout1_27ck530 FIND v(dout1_27) AT=270.025n

.meas tran vdout1_28ck530 FIND v(dout1_28) AT=270.025n

.meas tran vdout1_29ck530 FIND v(dout1_29) AT=270.025n

.meas tran vdout1_30ck530 FIND v(dout1_30) AT=270.025n

.meas tran vdout1_31ck530 FIND v(dout1_31) AT=270.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_16ck550 FIND v(dout1_16) AT=280.025n

.meas tran vdout1_17ck550 FIND v(dout1_17) AT=280.025n

.meas tran vdout1_18ck550 FIND v(dout1_18) AT=280.025n

.meas tran vdout1_19ck550 FIND v(dout1_19) AT=280.025n

.meas tran vdout1_20ck550 FIND v(dout1_20) AT=280.025n

.meas tran vdout1_21ck550 FIND v(dout1_21) AT=280.025n

.meas tran vdout1_22ck550 FIND v(dout1_22) AT=280.025n

.meas tran vdout1_23ck550 FIND v(dout1_23) AT=280.025n

.meas tran vdout1_24ck550 FIND v(dout1_24) AT=280.025n

.meas tran vdout1_25ck550 FIND v(dout1_25) AT=280.025n

.meas tran vdout1_26ck550 FIND v(dout1_26) AT=280.025n

.meas tran vdout1_27ck550 FIND v(dout1_27) AT=280.025n

.meas tran vdout1_28ck550 FIND v(dout1_28) AT=280.025n

.meas tran vdout1_29ck550 FIND v(dout1_29) AT=280.025n

.meas tran vdout1_30ck550 FIND v(dout1_30) AT=280.025n

.meas tran vdout1_31ck550 FIND v(dout1_31) AT=280.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_22ck570 FIND v(dout1_22) AT=290.025n

.meas tran vdout1_23ck570 FIND v(dout1_23) AT=290.025n

.meas tran vdout1_24ck570 FIND v(dout1_24) AT=290.025n

.meas tran vdout1_25ck570 FIND v(dout1_25) AT=290.025n

.meas tran vdout1_26ck570 FIND v(dout1_26) AT=290.025n

.meas tran vdout1_27ck570 FIND v(dout1_27) AT=290.025n

.meas tran vdout1_28ck570 FIND v(dout1_28) AT=290.025n

.meas tran vdout1_29ck570 FIND v(dout1_29) AT=290.025n

.meas tran vdout1_30ck570 FIND v(dout1_30) AT=290.025n

.meas tran vdout1_31ck570 FIND v(dout1_31) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_19ck580 FIND v(dout1_19) AT=295.025n

.meas tran vdout1_20ck580 FIND v(dout1_20) AT=295.025n

.meas tran vdout1_21ck580 FIND v(dout1_21) AT=295.025n

.meas tran vdout1_22ck580 FIND v(dout1_22) AT=295.025n

.meas tran vdout1_23ck580 FIND v(dout1_23) AT=295.025n

.meas tran vdout1_24ck580 FIND v(dout1_24) AT=295.025n

.meas tran vdout1_25ck580 FIND v(dout1_25) AT=295.025n

.meas tran vdout1_26ck580 FIND v(dout1_26) AT=295.025n

.meas tran vdout1_27ck580 FIND v(dout1_27) AT=295.025n

.meas tran vdout1_28ck580 FIND v(dout1_28) AT=295.025n

.meas tran vdout1_29ck580 FIND v(dout1_29) AT=295.025n

.meas tran vdout1_30ck580 FIND v(dout1_30) AT=295.025n

.meas tran vdout1_31ck580 FIND v(dout1_31) AT=295.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_17ck590 FIND v(dout1_17) AT=300.025n

.meas tran vdout1_18ck590 FIND v(dout1_18) AT=300.025n

.meas tran vdout1_19ck590 FIND v(dout1_19) AT=300.025n

.meas tran vdout1_20ck590 FIND v(dout1_20) AT=300.025n

.meas tran vdout1_21ck590 FIND v(dout1_21) AT=300.025n

.meas tran vdout1_22ck590 FIND v(dout1_22) AT=300.025n

.meas tran vdout1_23ck590 FIND v(dout1_23) AT=300.025n

.meas tran vdout1_24ck590 FIND v(dout1_24) AT=300.025n

.meas tran vdout1_25ck590 FIND v(dout1_25) AT=300.025n

.meas tran vdout1_26ck590 FIND v(dout1_26) AT=300.025n

.meas tran vdout1_27ck590 FIND v(dout1_27) AT=300.025n

.meas tran vdout1_28ck590 FIND v(dout1_28) AT=300.025n

.meas tran vdout1_29ck590 FIND v(dout1_29) AT=300.025n

.meas tran vdout1_30ck590 FIND v(dout1_30) AT=300.025n

.meas tran vdout1_31ck590 FIND v(dout1_31) AT=300.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_22ck610 FIND v(dout1_22) AT=310.025n

.meas tran vdout1_23ck610 FIND v(dout1_23) AT=310.025n

.meas tran vdout1_24ck610 FIND v(dout1_24) AT=310.025n

.meas tran vdout1_25ck610 FIND v(dout1_25) AT=310.025n

.meas tran vdout1_26ck610 FIND v(dout1_26) AT=310.025n

.meas tran vdout1_27ck610 FIND v(dout1_27) AT=310.025n

.meas tran vdout1_28ck610 FIND v(dout1_28) AT=310.025n

.meas tran vdout1_29ck610 FIND v(dout1_29) AT=310.025n

.meas tran vdout1_30ck610 FIND v(dout1_30) AT=310.025n

.meas tran vdout1_31ck610 FIND v(dout1_31) AT=310.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_8ck620 FIND v(dout1_8) AT=315.025n

.meas tran vdout1_9ck620 FIND v(dout1_9) AT=315.025n

.meas tran vdout1_10ck620 FIND v(dout1_10) AT=315.025n

.meas tran vdout1_11ck620 FIND v(dout1_11) AT=315.025n

.meas tran vdout1_12ck620 FIND v(dout1_12) AT=315.025n

.meas tran vdout1_13ck620 FIND v(dout1_13) AT=315.025n

.meas tran vdout1_14ck620 FIND v(dout1_14) AT=315.025n

.meas tran vdout1_15ck620 FIND v(dout1_15) AT=315.025n

.meas tran vdout1_16ck620 FIND v(dout1_16) AT=315.025n

.meas tran vdout1_17ck620 FIND v(dout1_17) AT=315.025n

.meas tran vdout1_18ck620 FIND v(dout1_18) AT=315.025n

.meas tran vdout1_19ck620 FIND v(dout1_19) AT=315.025n

.meas tran vdout1_20ck620 FIND v(dout1_20) AT=315.025n

.meas tran vdout1_21ck620 FIND v(dout1_21) AT=315.025n

.meas tran vdout1_22ck620 FIND v(dout1_22) AT=315.025n

.meas tran vdout1_23ck620 FIND v(dout1_23) AT=315.025n

.meas tran vdout1_24ck620 FIND v(dout1_24) AT=315.025n

.meas tran vdout1_25ck620 FIND v(dout1_25) AT=315.025n

.meas tran vdout1_26ck620 FIND v(dout1_26) AT=315.025n

.meas tran vdout1_27ck620 FIND v(dout1_27) AT=315.025n

.meas tran vdout1_28ck620 FIND v(dout1_28) AT=315.025n

.meas tran vdout1_29ck620 FIND v(dout1_29) AT=315.025n

.meas tran vdout1_30ck620 FIND v(dout1_30) AT=315.025n

.meas tran vdout1_31ck620 FIND v(dout1_31) AT=315.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_19ck650 FIND v(dout1_19) AT=330.025n

.meas tran vdout1_20ck650 FIND v(dout1_20) AT=330.025n

.meas tran vdout1_21ck650 FIND v(dout1_21) AT=330.025n

.meas tran vdout1_22ck650 FIND v(dout1_22) AT=330.025n

.meas tran vdout1_23ck650 FIND v(dout1_23) AT=330.025n

.meas tran vdout1_24ck650 FIND v(dout1_24) AT=330.025n

.meas tran vdout1_25ck650 FIND v(dout1_25) AT=330.025n

.meas tran vdout1_26ck650 FIND v(dout1_26) AT=330.025n

.meas tran vdout1_27ck650 FIND v(dout1_27) AT=330.025n

.meas tran vdout1_28ck650 FIND v(dout1_28) AT=330.025n

.meas tran vdout1_29ck650 FIND v(dout1_29) AT=330.025n

.meas tran vdout1_30ck650 FIND v(dout1_30) AT=330.025n

.meas tran vdout1_31ck650 FIND v(dout1_31) AT=330.025n

.meas tran vdout1_0ck690 FIND v(dout1_0) AT=350.025n

.meas tran vdout1_1ck690 FIND v(dout1_1) AT=350.025n

.meas tran vdout1_2ck690 FIND v(dout1_2) AT=350.025n

.meas tran vdout1_3ck690 FIND v(dout1_3) AT=350.025n

.meas tran vdout1_4ck690 FIND v(dout1_4) AT=350.025n

.meas tran vdout1_5ck690 FIND v(dout1_5) AT=350.025n

.meas tran vdout1_6ck690 FIND v(dout1_6) AT=350.025n

.meas tran vdout1_7ck690 FIND v(dout1_7) AT=350.025n

.meas tran vdout1_8ck690 FIND v(dout1_8) AT=350.025n

.meas tran vdout1_9ck690 FIND v(dout1_9) AT=350.025n

.meas tran vdout1_10ck690 FIND v(dout1_10) AT=350.025n

.meas tran vdout1_11ck690 FIND v(dout1_11) AT=350.025n

.meas tran vdout1_12ck690 FIND v(dout1_12) AT=350.025n

.meas tran vdout1_13ck690 FIND v(dout1_13) AT=350.025n

.meas tran vdout1_14ck690 FIND v(dout1_14) AT=350.025n

.meas tran vdout1_15ck690 FIND v(dout1_15) AT=350.025n

.meas tran vdout1_16ck690 FIND v(dout1_16) AT=350.025n

.meas tran vdout1_17ck690 FIND v(dout1_17) AT=350.025n

.meas tran vdout1_18ck690 FIND v(dout1_18) AT=350.025n

.meas tran vdout1_19ck690 FIND v(dout1_19) AT=350.025n

.meas tran vdout1_20ck690 FIND v(dout1_20) AT=350.025n

.meas tran vdout1_21ck690 FIND v(dout1_21) AT=350.025n

.meas tran vdout1_22ck690 FIND v(dout1_22) AT=350.025n

.meas tran vdout1_23ck690 FIND v(dout1_23) AT=350.025n

.meas tran vdout1_24ck690 FIND v(dout1_24) AT=350.025n

.meas tran vdout1_25ck690 FIND v(dout1_25) AT=350.025n

.meas tran vdout1_26ck690 FIND v(dout1_26) AT=350.025n

.meas tran vdout1_27ck690 FIND v(dout1_27) AT=350.025n

.meas tran vdout1_28ck690 FIND v(dout1_28) AT=350.025n

.meas tran vdout1_29ck690 FIND v(dout1_29) AT=350.025n

.meas tran vdout1_30ck690 FIND v(dout1_30) AT=350.025n

.meas tran vdout1_31ck690 FIND v(dout1_31) AT=350.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_19ck720 FIND v(dout1_19) AT=365.025n

.meas tran vdout1_20ck720 FIND v(dout1_20) AT=365.025n

.meas tran vdout1_21ck720 FIND v(dout1_21) AT=365.025n

.meas tran vdout1_22ck720 FIND v(dout1_22) AT=365.025n

.meas tran vdout1_23ck720 FIND v(dout1_23) AT=365.025n

.meas tran vdout1_24ck720 FIND v(dout1_24) AT=365.025n

.meas tran vdout1_25ck720 FIND v(dout1_25) AT=365.025n

.meas tran vdout1_26ck720 FIND v(dout1_26) AT=365.025n

.meas tran vdout1_27ck720 FIND v(dout1_27) AT=365.025n

.meas tran vdout1_28ck720 FIND v(dout1_28) AT=365.025n

.meas tran vdout1_29ck720 FIND v(dout1_29) AT=365.025n

.meas tran vdout1_30ck720 FIND v(dout1_30) AT=365.025n

.meas tran vdout1_31ck720 FIND v(dout1_31) AT=365.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_23ck770 FIND v(dout1_23) AT=390.025n

.meas tran vdout1_24ck770 FIND v(dout1_24) AT=390.025n

.meas tran vdout1_25ck770 FIND v(dout1_25) AT=390.025n

.meas tran vdout1_26ck770 FIND v(dout1_26) AT=390.025n

.meas tran vdout1_27ck770 FIND v(dout1_27) AT=390.025n

.meas tran vdout1_28ck770 FIND v(dout1_28) AT=390.025n

.meas tran vdout1_29ck770 FIND v(dout1_29) AT=390.025n

.meas tran vdout1_30ck770 FIND v(dout1_30) AT=390.025n

.meas tran vdout1_31ck770 FIND v(dout1_31) AT=390.025n

.meas tran vdout1_0ck780 FIND v(dout1_0) AT=395.025n

.meas tran vdout1_1ck780 FIND v(dout1_1) AT=395.025n

.meas tran vdout1_2ck780 FIND v(dout1_2) AT=395.025n

.meas tran vdout1_3ck780 FIND v(dout1_3) AT=395.025n

.meas tran vdout1_4ck780 FIND v(dout1_4) AT=395.025n

.meas tran vdout1_5ck780 FIND v(dout1_5) AT=395.025n

.meas tran vdout1_6ck780 FIND v(dout1_6) AT=395.025n

.meas tran vdout1_7ck780 FIND v(dout1_7) AT=395.025n

.meas tran vdout1_8ck780 FIND v(dout1_8) AT=395.025n

.meas tran vdout1_9ck780 FIND v(dout1_9) AT=395.025n

.meas tran vdout1_10ck780 FIND v(dout1_10) AT=395.025n

.meas tran vdout1_11ck780 FIND v(dout1_11) AT=395.025n

.meas tran vdout1_12ck780 FIND v(dout1_12) AT=395.025n

.meas tran vdout1_13ck780 FIND v(dout1_13) AT=395.025n

.meas tran vdout1_14ck780 FIND v(dout1_14) AT=395.025n

.meas tran vdout1_15ck780 FIND v(dout1_15) AT=395.025n

.meas tran vdout1_16ck780 FIND v(dout1_16) AT=395.025n

.meas tran vdout1_17ck780 FIND v(dout1_17) AT=395.025n

.meas tran vdout1_18ck780 FIND v(dout1_18) AT=395.025n

.meas tran vdout1_19ck780 FIND v(dout1_19) AT=395.025n

.meas tran vdout1_20ck780 FIND v(dout1_20) AT=395.025n

.meas tran vdout1_21ck780 FIND v(dout1_21) AT=395.025n

.meas tran vdout1_22ck780 FIND v(dout1_22) AT=395.025n

.meas tran vdout1_23ck780 FIND v(dout1_23) AT=395.025n

.meas tran vdout1_24ck780 FIND v(dout1_24) AT=395.025n

.meas tran vdout1_25ck780 FIND v(dout1_25) AT=395.025n

.meas tran vdout1_26ck780 FIND v(dout1_26) AT=395.025n

.meas tran vdout1_27ck780 FIND v(dout1_27) AT=395.025n

.meas tran vdout1_28ck780 FIND v(dout1_28) AT=395.025n

.meas tran vdout1_29ck780 FIND v(dout1_29) AT=395.025n

.meas tran vdout1_30ck780 FIND v(dout1_30) AT=395.025n

.meas tran vdout1_31ck780 FIND v(dout1_31) AT=395.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_16ck820 FIND v(dout1_16) AT=415.025n

.meas tran vdout1_17ck820 FIND v(dout1_17) AT=415.025n

.meas tran vdout1_18ck820 FIND v(dout1_18) AT=415.025n

.meas tran vdout1_19ck820 FIND v(dout1_19) AT=415.025n

.meas tran vdout1_20ck820 FIND v(dout1_20) AT=415.025n

.meas tran vdout1_21ck820 FIND v(dout1_21) AT=415.025n

.meas tran vdout1_22ck820 FIND v(dout1_22) AT=415.025n

.meas tran vdout1_23ck820 FIND v(dout1_23) AT=415.025n

.meas tran vdout1_24ck820 FIND v(dout1_24) AT=415.025n

.meas tran vdout1_25ck820 FIND v(dout1_25) AT=415.025n

.meas tran vdout1_26ck820 FIND v(dout1_26) AT=415.025n

.meas tran vdout1_27ck820 FIND v(dout1_27) AT=415.025n

.meas tran vdout1_28ck820 FIND v(dout1_28) AT=415.025n

.meas tran vdout1_29ck820 FIND v(dout1_29) AT=415.025n

.meas tran vdout1_30ck820 FIND v(dout1_30) AT=415.025n

.meas tran vdout1_31ck820 FIND v(dout1_31) AT=415.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_0ck840 FIND v(dout1_0) AT=425.025n

.meas tran vdout1_1ck840 FIND v(dout1_1) AT=425.025n

.meas tran vdout1_2ck840 FIND v(dout1_2) AT=425.025n

.meas tran vdout1_3ck840 FIND v(dout1_3) AT=425.025n

.meas tran vdout1_4ck840 FIND v(dout1_4) AT=425.025n

.meas tran vdout1_5ck840 FIND v(dout1_5) AT=425.025n

.meas tran vdout1_6ck840 FIND v(dout1_6) AT=425.025n

.meas tran vdout1_7ck840 FIND v(dout1_7) AT=425.025n

.meas tran vdout1_8ck840 FIND v(dout1_8) AT=425.025n

.meas tran vdout1_9ck840 FIND v(dout1_9) AT=425.025n

.meas tran vdout1_10ck840 FIND v(dout1_10) AT=425.025n

.meas tran vdout1_11ck840 FIND v(dout1_11) AT=425.025n

.meas tran vdout1_12ck840 FIND v(dout1_12) AT=425.025n

.meas tran vdout1_13ck840 FIND v(dout1_13) AT=425.025n

.meas tran vdout1_14ck840 FIND v(dout1_14) AT=425.025n

.meas tran vdout1_15ck840 FIND v(dout1_15) AT=425.025n

.meas tran vdout1_16ck840 FIND v(dout1_16) AT=425.025n

.meas tran vdout1_17ck840 FIND v(dout1_17) AT=425.025n

.meas tran vdout1_18ck840 FIND v(dout1_18) AT=425.025n

.meas tran vdout1_19ck840 FIND v(dout1_19) AT=425.025n

.meas tran vdout1_20ck840 FIND v(dout1_20) AT=425.025n

.meas tran vdout1_21ck840 FIND v(dout1_21) AT=425.025n

.meas tran vdout1_22ck840 FIND v(dout1_22) AT=425.025n

.meas tran vdout1_23ck840 FIND v(dout1_23) AT=425.025n

.meas tran vdout1_24ck840 FIND v(dout1_24) AT=425.025n

.meas tran vdout1_25ck840 FIND v(dout1_25) AT=425.025n

.meas tran vdout1_26ck840 FIND v(dout1_26) AT=425.025n

.meas tran vdout1_27ck840 FIND v(dout1_27) AT=425.025n

.meas tran vdout1_28ck840 FIND v(dout1_28) AT=425.025n

.meas tran vdout1_29ck840 FIND v(dout1_29) AT=425.025n

.meas tran vdout1_30ck840 FIND v(dout1_30) AT=425.025n

.meas tran vdout1_31ck840 FIND v(dout1_31) AT=425.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_19ck850 FIND v(dout1_19) AT=430.025n

.meas tran vdout1_20ck850 FIND v(dout1_20) AT=430.025n

.meas tran vdout1_21ck850 FIND v(dout1_21) AT=430.025n

.meas tran vdout1_22ck850 FIND v(dout1_22) AT=430.025n

.meas tran vdout1_23ck850 FIND v(dout1_23) AT=430.025n

.meas tran vdout1_24ck850 FIND v(dout1_24) AT=430.025n

.meas tran vdout1_25ck850 FIND v(dout1_25) AT=430.025n

.meas tran vdout1_26ck850 FIND v(dout1_26) AT=430.025n

.meas tran vdout1_27ck850 FIND v(dout1_27) AT=430.025n

.meas tran vdout1_28ck850 FIND v(dout1_28) AT=430.025n

.meas tran vdout1_29ck850 FIND v(dout1_29) AT=430.025n

.meas tran vdout1_30ck850 FIND v(dout1_30) AT=430.025n

.meas tran vdout1_31ck850 FIND v(dout1_31) AT=430.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_0ck940 FIND v(dout1_0) AT=475.025n

.meas tran vdout1_1ck940 FIND v(dout1_1) AT=475.025n

.meas tran vdout1_2ck940 FIND v(dout1_2) AT=475.025n

.meas tran vdout1_3ck940 FIND v(dout1_3) AT=475.025n

.meas tran vdout1_4ck940 FIND v(dout1_4) AT=475.025n

.meas tran vdout1_5ck940 FIND v(dout1_5) AT=475.025n

.meas tran vdout1_6ck940 FIND v(dout1_6) AT=475.025n

.meas tran vdout1_7ck940 FIND v(dout1_7) AT=475.025n

.meas tran vdout1_8ck940 FIND v(dout1_8) AT=475.025n

.meas tran vdout1_9ck940 FIND v(dout1_9) AT=475.025n

.meas tran vdout1_10ck940 FIND v(dout1_10) AT=475.025n

.meas tran vdout1_11ck940 FIND v(dout1_11) AT=475.025n

.meas tran vdout1_12ck940 FIND v(dout1_12) AT=475.025n

.meas tran vdout1_13ck940 FIND v(dout1_13) AT=475.025n

.meas tran vdout1_14ck940 FIND v(dout1_14) AT=475.025n

.meas tran vdout1_15ck940 FIND v(dout1_15) AT=475.025n

.meas tran vdout1_16ck940 FIND v(dout1_16) AT=475.025n

.meas tran vdout1_17ck940 FIND v(dout1_17) AT=475.025n

.meas tran vdout1_18ck940 FIND v(dout1_18) AT=475.025n

.meas tran vdout1_19ck940 FIND v(dout1_19) AT=475.025n

.meas tran vdout1_20ck940 FIND v(dout1_20) AT=475.025n

.meas tran vdout1_21ck940 FIND v(dout1_21) AT=475.025n

.meas tran vdout1_22ck940 FIND v(dout1_22) AT=475.025n

.meas tran vdout1_23ck940 FIND v(dout1_23) AT=475.025n

.meas tran vdout1_24ck940 FIND v(dout1_24) AT=475.025n

.meas tran vdout1_25ck940 FIND v(dout1_25) AT=475.025n

.meas tran vdout1_26ck940 FIND v(dout1_26) AT=475.025n

.meas tran vdout1_27ck940 FIND v(dout1_27) AT=475.025n

.meas tran vdout1_28ck940 FIND v(dout1_28) AT=475.025n

.meas tran vdout1_29ck940 FIND v(dout1_29) AT=475.025n

.meas tran vdout1_30ck940 FIND v(dout1_30) AT=475.025n

.meas tran vdout1_31ck940 FIND v(dout1_31) AT=475.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_22ck950 FIND v(dout1_22) AT=480.025n

.meas tran vdout1_23ck950 FIND v(dout1_23) AT=480.025n

.meas tran vdout1_24ck950 FIND v(dout1_24) AT=480.025n

.meas tran vdout1_25ck950 FIND v(dout1_25) AT=480.025n

.meas tran vdout1_26ck950 FIND v(dout1_26) AT=480.025n

.meas tran vdout1_27ck950 FIND v(dout1_27) AT=480.025n

.meas tran vdout1_28ck950 FIND v(dout1_28) AT=480.025n

.meas tran vdout1_29ck950 FIND v(dout1_29) AT=480.025n

.meas tran vdout1_30ck950 FIND v(dout1_30) AT=480.025n

.meas tran vdout1_31ck950 FIND v(dout1_31) AT=480.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_23ck990 FIND v(dout1_23) AT=500.025n

.meas tran vdout1_24ck990 FIND v(dout1_24) AT=500.025n

.meas tran vdout1_25ck990 FIND v(dout1_25) AT=500.025n

.meas tran vdout1_26ck990 FIND v(dout1_26) AT=500.025n

.meas tran vdout1_27ck990 FIND v(dout1_27) AT=500.025n

.meas tran vdout1_28ck990 FIND v(dout1_28) AT=500.025n

.meas tran vdout1_29ck990 FIND v(dout1_29) AT=500.025n

.meas tran vdout1_30ck990 FIND v(dout1_30) AT=500.025n

.meas tran vdout1_31ck990 FIND v(dout1_31) AT=500.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_16ck1030 FIND v(dout1_16) AT=520.025n

.meas tran vdout1_17ck1030 FIND v(dout1_17) AT=520.025n

.meas tran vdout1_18ck1030 FIND v(dout1_18) AT=520.025n

.meas tran vdout1_19ck1030 FIND v(dout1_19) AT=520.025n

.meas tran vdout1_20ck1030 FIND v(dout1_20) AT=520.025n

.meas tran vdout1_21ck1030 FIND v(dout1_21) AT=520.025n

.meas tran vdout1_22ck1030 FIND v(dout1_22) AT=520.025n

.meas tran vdout1_23ck1030 FIND v(dout1_23) AT=520.025n

.meas tran vdout1_24ck1030 FIND v(dout1_24) AT=520.025n

.meas tran vdout1_25ck1030 FIND v(dout1_25) AT=520.025n

.meas tran vdout1_26ck1030 FIND v(dout1_26) AT=520.025n

.meas tran vdout1_27ck1030 FIND v(dout1_27) AT=520.025n

.meas tran vdout1_28ck1030 FIND v(dout1_28) AT=520.025n

.meas tran vdout1_29ck1030 FIND v(dout1_29) AT=520.025n

.meas tran vdout1_30ck1030 FIND v(dout1_30) AT=520.025n

.meas tran vdout1_31ck1030 FIND v(dout1_31) AT=520.025n

.meas tran vdout1_0ck1040 FIND v(dout1_0) AT=525.025n

.meas tran vdout1_1ck1040 FIND v(dout1_1) AT=525.025n

.meas tran vdout1_2ck1040 FIND v(dout1_2) AT=525.025n

.meas tran vdout1_3ck1040 FIND v(dout1_3) AT=525.025n

.meas tran vdout1_4ck1040 FIND v(dout1_4) AT=525.025n

.meas tran vdout1_5ck1040 FIND v(dout1_5) AT=525.025n

.meas tran vdout1_6ck1040 FIND v(dout1_6) AT=525.025n

.meas tran vdout1_7ck1040 FIND v(dout1_7) AT=525.025n

.meas tran vdout1_8ck1040 FIND v(dout1_8) AT=525.025n

.meas tran vdout1_9ck1040 FIND v(dout1_9) AT=525.025n

.meas tran vdout1_10ck1040 FIND v(dout1_10) AT=525.025n

.meas tran vdout1_11ck1040 FIND v(dout1_11) AT=525.025n

.meas tran vdout1_12ck1040 FIND v(dout1_12) AT=525.025n

.meas tran vdout1_13ck1040 FIND v(dout1_13) AT=525.025n

.meas tran vdout1_14ck1040 FIND v(dout1_14) AT=525.025n

.meas tran vdout1_15ck1040 FIND v(dout1_15) AT=525.025n

.meas tran vdout1_16ck1040 FIND v(dout1_16) AT=525.025n

.meas tran vdout1_17ck1040 FIND v(dout1_17) AT=525.025n

.meas tran vdout1_18ck1040 FIND v(dout1_18) AT=525.025n

.meas tran vdout1_19ck1040 FIND v(dout1_19) AT=525.025n

.meas tran vdout1_20ck1040 FIND v(dout1_20) AT=525.025n

.meas tran vdout1_21ck1040 FIND v(dout1_21) AT=525.025n

.meas tran vdout1_22ck1040 FIND v(dout1_22) AT=525.025n

.meas tran vdout1_23ck1040 FIND v(dout1_23) AT=525.025n

.meas tran vdout1_24ck1040 FIND v(dout1_24) AT=525.025n

.meas tran vdout1_25ck1040 FIND v(dout1_25) AT=525.025n

.meas tran vdout1_26ck1040 FIND v(dout1_26) AT=525.025n

.meas tran vdout1_27ck1040 FIND v(dout1_27) AT=525.025n

.meas tran vdout1_28ck1040 FIND v(dout1_28) AT=525.025n

.meas tran vdout1_29ck1040 FIND v(dout1_29) AT=525.025n

.meas tran vdout1_30ck1040 FIND v(dout1_30) AT=525.025n

.meas tran vdout1_31ck1040 FIND v(dout1_31) AT=525.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_16ck1060 FIND v(dout1_16) AT=535.025n

.meas tran vdout1_17ck1060 FIND v(dout1_17) AT=535.025n

.meas tran vdout1_18ck1060 FIND v(dout1_18) AT=535.025n

.meas tran vdout1_19ck1060 FIND v(dout1_19) AT=535.025n

.meas tran vdout1_20ck1060 FIND v(dout1_20) AT=535.025n

.meas tran vdout1_21ck1060 FIND v(dout1_21) AT=535.025n

.meas tran vdout1_22ck1060 FIND v(dout1_22) AT=535.025n

.meas tran vdout1_23ck1060 FIND v(dout1_23) AT=535.025n

.meas tran vdout1_24ck1060 FIND v(dout1_24) AT=535.025n

.meas tran vdout1_25ck1060 FIND v(dout1_25) AT=535.025n

.meas tran vdout1_26ck1060 FIND v(dout1_26) AT=535.025n

.meas tran vdout1_27ck1060 FIND v(dout1_27) AT=535.025n

.meas tran vdout1_28ck1060 FIND v(dout1_28) AT=535.025n

.meas tran vdout1_29ck1060 FIND v(dout1_29) AT=535.025n

.meas tran vdout1_30ck1060 FIND v(dout1_30) AT=535.025n

.meas tran vdout1_31ck1060 FIND v(dout1_31) AT=535.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_8ck1070 FIND v(dout1_8) AT=540.025n

.meas tran vdout1_9ck1070 FIND v(dout1_9) AT=540.025n

.meas tran vdout1_10ck1070 FIND v(dout1_10) AT=540.025n

.meas tran vdout1_11ck1070 FIND v(dout1_11) AT=540.025n

.meas tran vdout1_12ck1070 FIND v(dout1_12) AT=540.025n

.meas tran vdout1_13ck1070 FIND v(dout1_13) AT=540.025n

.meas tran vdout1_14ck1070 FIND v(dout1_14) AT=540.025n

.meas tran vdout1_15ck1070 FIND v(dout1_15) AT=540.025n

.meas tran vdout1_16ck1070 FIND v(dout1_16) AT=540.025n

.meas tran vdout1_17ck1070 FIND v(dout1_17) AT=540.025n

.meas tran vdout1_18ck1070 FIND v(dout1_18) AT=540.025n

.meas tran vdout1_19ck1070 FIND v(dout1_19) AT=540.025n

.meas tran vdout1_20ck1070 FIND v(dout1_20) AT=540.025n

.meas tran vdout1_21ck1070 FIND v(dout1_21) AT=540.025n

.meas tran vdout1_22ck1070 FIND v(dout1_22) AT=540.025n

.meas tran vdout1_23ck1070 FIND v(dout1_23) AT=540.025n

.meas tran vdout1_24ck1070 FIND v(dout1_24) AT=540.025n

.meas tran vdout1_25ck1070 FIND v(dout1_25) AT=540.025n

.meas tran vdout1_26ck1070 FIND v(dout1_26) AT=540.025n

.meas tran vdout1_27ck1070 FIND v(dout1_27) AT=540.025n

.meas tran vdout1_28ck1070 FIND v(dout1_28) AT=540.025n

.meas tran vdout1_29ck1070 FIND v(dout1_29) AT=540.025n

.meas tran vdout1_30ck1070 FIND v(dout1_30) AT=540.025n

.meas tran vdout1_31ck1070 FIND v(dout1_31) AT=540.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_19ck1110 FIND v(dout1_19) AT=560.025n

.meas tran vdout1_20ck1110 FIND v(dout1_20) AT=560.025n

.meas tran vdout1_21ck1110 FIND v(dout1_21) AT=560.025n

.meas tran vdout1_22ck1110 FIND v(dout1_22) AT=560.025n

.meas tran vdout1_23ck1110 FIND v(dout1_23) AT=560.025n

.meas tran vdout1_24ck1110 FIND v(dout1_24) AT=560.025n

.meas tran vdout1_25ck1110 FIND v(dout1_25) AT=560.025n

.meas tran vdout1_26ck1110 FIND v(dout1_26) AT=560.025n

.meas tran vdout1_27ck1110 FIND v(dout1_27) AT=560.025n

.meas tran vdout1_28ck1110 FIND v(dout1_28) AT=560.025n

.meas tran vdout1_29ck1110 FIND v(dout1_29) AT=560.025n

.meas tran vdout1_30ck1110 FIND v(dout1_30) AT=560.025n

.meas tran vdout1_31ck1110 FIND v(dout1_31) AT=560.025n

.meas tran vdout1_0ck1130 FIND v(dout1_0) AT=570.025n

.meas tran vdout1_1ck1130 FIND v(dout1_1) AT=570.025n

.meas tran vdout1_2ck1130 FIND v(dout1_2) AT=570.025n

.meas tran vdout1_3ck1130 FIND v(dout1_3) AT=570.025n

.meas tran vdout1_4ck1130 FIND v(dout1_4) AT=570.025n

.meas tran vdout1_5ck1130 FIND v(dout1_5) AT=570.025n

.meas tran vdout1_6ck1130 FIND v(dout1_6) AT=570.025n

.meas tran vdout1_7ck1130 FIND v(dout1_7) AT=570.025n

.meas tran vdout1_8ck1130 FIND v(dout1_8) AT=570.025n

.meas tran vdout1_9ck1130 FIND v(dout1_9) AT=570.025n

.meas tran vdout1_10ck1130 FIND v(dout1_10) AT=570.025n

.meas tran vdout1_11ck1130 FIND v(dout1_11) AT=570.025n

.meas tran vdout1_12ck1130 FIND v(dout1_12) AT=570.025n

.meas tran vdout1_13ck1130 FIND v(dout1_13) AT=570.025n

.meas tran vdout1_14ck1130 FIND v(dout1_14) AT=570.025n

.meas tran vdout1_15ck1130 FIND v(dout1_15) AT=570.025n

.meas tran vdout1_16ck1130 FIND v(dout1_16) AT=570.025n

.meas tran vdout1_17ck1130 FIND v(dout1_17) AT=570.025n

.meas tran vdout1_18ck1130 FIND v(dout1_18) AT=570.025n

.meas tran vdout1_19ck1130 FIND v(dout1_19) AT=570.025n

.meas tran vdout1_20ck1130 FIND v(dout1_20) AT=570.025n

.meas tran vdout1_21ck1130 FIND v(dout1_21) AT=570.025n

.meas tran vdout1_22ck1130 FIND v(dout1_22) AT=570.025n

.meas tran vdout1_23ck1130 FIND v(dout1_23) AT=570.025n

.meas tran vdout1_24ck1130 FIND v(dout1_24) AT=570.025n

.meas tran vdout1_25ck1130 FIND v(dout1_25) AT=570.025n

.meas tran vdout1_26ck1130 FIND v(dout1_26) AT=570.025n

.meas tran vdout1_27ck1130 FIND v(dout1_27) AT=570.025n

.meas tran vdout1_28ck1130 FIND v(dout1_28) AT=570.025n

.meas tran vdout1_29ck1130 FIND v(dout1_29) AT=570.025n

.meas tran vdout1_30ck1130 FIND v(dout1_30) AT=570.025n

.meas tran vdout1_31ck1130 FIND v(dout1_31) AT=570.025n

.meas tran vdout1_0ck1140 FIND v(dout1_0) AT=575.025n

.meas tran vdout1_1ck1140 FIND v(dout1_1) AT=575.025n

.meas tran vdout1_2ck1140 FIND v(dout1_2) AT=575.025n

.meas tran vdout1_3ck1140 FIND v(dout1_3) AT=575.025n

.meas tran vdout1_4ck1140 FIND v(dout1_4) AT=575.025n

.meas tran vdout1_5ck1140 FIND v(dout1_5) AT=575.025n

.meas tran vdout1_6ck1140 FIND v(dout1_6) AT=575.025n

.meas tran vdout1_7ck1140 FIND v(dout1_7) AT=575.025n

.meas tran vdout1_8ck1140 FIND v(dout1_8) AT=575.025n

.meas tran vdout1_9ck1140 FIND v(dout1_9) AT=575.025n

.meas tran vdout1_10ck1140 FIND v(dout1_10) AT=575.025n

.meas tran vdout1_11ck1140 FIND v(dout1_11) AT=575.025n

.meas tran vdout1_12ck1140 FIND v(dout1_12) AT=575.025n

.meas tran vdout1_13ck1140 FIND v(dout1_13) AT=575.025n

.meas tran vdout1_14ck1140 FIND v(dout1_14) AT=575.025n

.meas tran vdout1_15ck1140 FIND v(dout1_15) AT=575.025n

.meas tran vdout1_16ck1140 FIND v(dout1_16) AT=575.025n

.meas tran vdout1_17ck1140 FIND v(dout1_17) AT=575.025n

.meas tran vdout1_18ck1140 FIND v(dout1_18) AT=575.025n

.meas tran vdout1_19ck1140 FIND v(dout1_19) AT=575.025n

.meas tran vdout1_20ck1140 FIND v(dout1_20) AT=575.025n

.meas tran vdout1_21ck1140 FIND v(dout1_21) AT=575.025n

.meas tran vdout1_22ck1140 FIND v(dout1_22) AT=575.025n

.meas tran vdout1_23ck1140 FIND v(dout1_23) AT=575.025n

.meas tran vdout1_24ck1140 FIND v(dout1_24) AT=575.025n

.meas tran vdout1_25ck1140 FIND v(dout1_25) AT=575.025n

.meas tran vdout1_26ck1140 FIND v(dout1_26) AT=575.025n

.meas tran vdout1_27ck1140 FIND v(dout1_27) AT=575.025n

.meas tran vdout1_28ck1140 FIND v(dout1_28) AT=575.025n

.meas tran vdout1_29ck1140 FIND v(dout1_29) AT=575.025n

.meas tran vdout1_30ck1140 FIND v(dout1_30) AT=575.025n

.meas tran vdout1_31ck1140 FIND v(dout1_31) AT=575.025n

.meas tran vdout1_0ck1150 FIND v(dout1_0) AT=580.025n

.meas tran vdout1_1ck1150 FIND v(dout1_1) AT=580.025n

.meas tran vdout1_2ck1150 FIND v(dout1_2) AT=580.025n

.meas tran vdout1_3ck1150 FIND v(dout1_3) AT=580.025n

.meas tran vdout1_4ck1150 FIND v(dout1_4) AT=580.025n

.meas tran vdout1_5ck1150 FIND v(dout1_5) AT=580.025n

.meas tran vdout1_6ck1150 FIND v(dout1_6) AT=580.025n

.meas tran vdout1_7ck1150 FIND v(dout1_7) AT=580.025n

.meas tran vdout1_8ck1150 FIND v(dout1_8) AT=580.025n

.meas tran vdout1_9ck1150 FIND v(dout1_9) AT=580.025n

.meas tran vdout1_10ck1150 FIND v(dout1_10) AT=580.025n

.meas tran vdout1_11ck1150 FIND v(dout1_11) AT=580.025n

.meas tran vdout1_12ck1150 FIND v(dout1_12) AT=580.025n

.meas tran vdout1_13ck1150 FIND v(dout1_13) AT=580.025n

.meas tran vdout1_14ck1150 FIND v(dout1_14) AT=580.025n

.meas tran vdout1_15ck1150 FIND v(dout1_15) AT=580.025n

.meas tran vdout1_16ck1150 FIND v(dout1_16) AT=580.025n

.meas tran vdout1_17ck1150 FIND v(dout1_17) AT=580.025n

.meas tran vdout1_18ck1150 FIND v(dout1_18) AT=580.025n

.meas tran vdout1_19ck1150 FIND v(dout1_19) AT=580.025n

.meas tran vdout1_20ck1150 FIND v(dout1_20) AT=580.025n

.meas tran vdout1_21ck1150 FIND v(dout1_21) AT=580.025n

.meas tran vdout1_22ck1150 FIND v(dout1_22) AT=580.025n

.meas tran vdout1_23ck1150 FIND v(dout1_23) AT=580.025n

.meas tran vdout1_24ck1150 FIND v(dout1_24) AT=580.025n

.meas tran vdout1_25ck1150 FIND v(dout1_25) AT=580.025n

.meas tran vdout1_26ck1150 FIND v(dout1_26) AT=580.025n

.meas tran vdout1_27ck1150 FIND v(dout1_27) AT=580.025n

.meas tran vdout1_28ck1150 FIND v(dout1_28) AT=580.025n

.meas tran vdout1_29ck1150 FIND v(dout1_29) AT=580.025n

.meas tran vdout1_30ck1150 FIND v(dout1_30) AT=580.025n

.meas tran vdout1_31ck1150 FIND v(dout1_31) AT=580.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_17ck1160 FIND v(dout1_17) AT=585.025n

.meas tran vdout1_18ck1160 FIND v(dout1_18) AT=585.025n

.meas tran vdout1_19ck1160 FIND v(dout1_19) AT=585.025n

.meas tran vdout1_20ck1160 FIND v(dout1_20) AT=585.025n

.meas tran vdout1_21ck1160 FIND v(dout1_21) AT=585.025n

.meas tran vdout1_22ck1160 FIND v(dout1_22) AT=585.025n

.meas tran vdout1_23ck1160 FIND v(dout1_23) AT=585.025n

.meas tran vdout1_24ck1160 FIND v(dout1_24) AT=585.025n

.meas tran vdout1_25ck1160 FIND v(dout1_25) AT=585.025n

.meas tran vdout1_26ck1160 FIND v(dout1_26) AT=585.025n

.meas tran vdout1_27ck1160 FIND v(dout1_27) AT=585.025n

.meas tran vdout1_28ck1160 FIND v(dout1_28) AT=585.025n

.meas tran vdout1_29ck1160 FIND v(dout1_29) AT=585.025n

.meas tran vdout1_30ck1160 FIND v(dout1_30) AT=585.025n

.meas tran vdout1_31ck1160 FIND v(dout1_31) AT=585.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_16ck1210 FIND v(dout1_16) AT=610.025n

.meas tran vdout1_17ck1210 FIND v(dout1_17) AT=610.025n

.meas tran vdout1_18ck1210 FIND v(dout1_18) AT=610.025n

.meas tran vdout1_19ck1210 FIND v(dout1_19) AT=610.025n

.meas tran vdout1_20ck1210 FIND v(dout1_20) AT=610.025n

.meas tran vdout1_21ck1210 FIND v(dout1_21) AT=610.025n

.meas tran vdout1_22ck1210 FIND v(dout1_22) AT=610.025n

.meas tran vdout1_23ck1210 FIND v(dout1_23) AT=610.025n

.meas tran vdout1_24ck1210 FIND v(dout1_24) AT=610.025n

.meas tran vdout1_25ck1210 FIND v(dout1_25) AT=610.025n

.meas tran vdout1_26ck1210 FIND v(dout1_26) AT=610.025n

.meas tran vdout1_27ck1210 FIND v(dout1_27) AT=610.025n

.meas tran vdout1_28ck1210 FIND v(dout1_28) AT=610.025n

.meas tran vdout1_29ck1210 FIND v(dout1_29) AT=610.025n

.meas tran vdout1_30ck1210 FIND v(dout1_30) AT=610.025n

.meas tran vdout1_31ck1210 FIND v(dout1_31) AT=610.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_17ck1230 FIND v(dout1_17) AT=620.025n

.meas tran vdout1_18ck1230 FIND v(dout1_18) AT=620.025n

.meas tran vdout1_19ck1230 FIND v(dout1_19) AT=620.025n

.meas tran vdout1_20ck1230 FIND v(dout1_20) AT=620.025n

.meas tran vdout1_21ck1230 FIND v(dout1_21) AT=620.025n

.meas tran vdout1_22ck1230 FIND v(dout1_22) AT=620.025n

.meas tran vdout1_23ck1230 FIND v(dout1_23) AT=620.025n

.meas tran vdout1_24ck1230 FIND v(dout1_24) AT=620.025n

.meas tran vdout1_25ck1230 FIND v(dout1_25) AT=620.025n

.meas tran vdout1_26ck1230 FIND v(dout1_26) AT=620.025n

.meas tran vdout1_27ck1230 FIND v(dout1_27) AT=620.025n

.meas tran vdout1_28ck1230 FIND v(dout1_28) AT=620.025n

.meas tran vdout1_29ck1230 FIND v(dout1_29) AT=620.025n

.meas tran vdout1_30ck1230 FIND v(dout1_30) AT=620.025n

.meas tran vdout1_31ck1230 FIND v(dout1_31) AT=620.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_17ck1260 FIND v(dout1_17) AT=635.025n

.meas tran vdout1_18ck1260 FIND v(dout1_18) AT=635.025n

.meas tran vdout1_19ck1260 FIND v(dout1_19) AT=635.025n

.meas tran vdout1_20ck1260 FIND v(dout1_20) AT=635.025n

.meas tran vdout1_21ck1260 FIND v(dout1_21) AT=635.025n

.meas tran vdout1_22ck1260 FIND v(dout1_22) AT=635.025n

.meas tran vdout1_23ck1260 FIND v(dout1_23) AT=635.025n

.meas tran vdout1_24ck1260 FIND v(dout1_24) AT=635.025n

.meas tran vdout1_25ck1260 FIND v(dout1_25) AT=635.025n

.meas tran vdout1_26ck1260 FIND v(dout1_26) AT=635.025n

.meas tran vdout1_27ck1260 FIND v(dout1_27) AT=635.025n

.meas tran vdout1_28ck1260 FIND v(dout1_28) AT=635.025n

.meas tran vdout1_29ck1260 FIND v(dout1_29) AT=635.025n

.meas tran vdout1_30ck1260 FIND v(dout1_30) AT=635.025n

.meas tran vdout1_31ck1260 FIND v(dout1_31) AT=635.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_16ck1280 FIND v(dout1_16) AT=645.025n

.meas tran vdout1_17ck1280 FIND v(dout1_17) AT=645.025n

.meas tran vdout1_18ck1280 FIND v(dout1_18) AT=645.025n

.meas tran vdout1_19ck1280 FIND v(dout1_19) AT=645.025n

.meas tran vdout1_20ck1280 FIND v(dout1_20) AT=645.025n

.meas tran vdout1_21ck1280 FIND v(dout1_21) AT=645.025n

.meas tran vdout1_22ck1280 FIND v(dout1_22) AT=645.025n

.meas tran vdout1_23ck1280 FIND v(dout1_23) AT=645.025n

.meas tran vdout1_24ck1280 FIND v(dout1_24) AT=645.025n

.meas tran vdout1_25ck1280 FIND v(dout1_25) AT=645.025n

.meas tran vdout1_26ck1280 FIND v(dout1_26) AT=645.025n

.meas tran vdout1_27ck1280 FIND v(dout1_27) AT=645.025n

.meas tran vdout1_28ck1280 FIND v(dout1_28) AT=645.025n

.meas tran vdout1_29ck1280 FIND v(dout1_29) AT=645.025n

.meas tran vdout1_30ck1280 FIND v(dout1_30) AT=645.025n

.meas tran vdout1_31ck1280 FIND v(dout1_31) AT=645.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_16ck1360 FIND v(dout1_16) AT=685.025n

.meas tran vdout1_17ck1360 FIND v(dout1_17) AT=685.025n

.meas tran vdout1_18ck1360 FIND v(dout1_18) AT=685.025n

.meas tran vdout1_19ck1360 FIND v(dout1_19) AT=685.025n

.meas tran vdout1_20ck1360 FIND v(dout1_20) AT=685.025n

.meas tran vdout1_21ck1360 FIND v(dout1_21) AT=685.025n

.meas tran vdout1_22ck1360 FIND v(dout1_22) AT=685.025n

.meas tran vdout1_23ck1360 FIND v(dout1_23) AT=685.025n

.meas tran vdout1_24ck1360 FIND v(dout1_24) AT=685.025n

.meas tran vdout1_25ck1360 FIND v(dout1_25) AT=685.025n

.meas tran vdout1_26ck1360 FIND v(dout1_26) AT=685.025n

.meas tran vdout1_27ck1360 FIND v(dout1_27) AT=685.025n

.meas tran vdout1_28ck1360 FIND v(dout1_28) AT=685.025n

.meas tran vdout1_29ck1360 FIND v(dout1_29) AT=685.025n

.meas tran vdout1_30ck1360 FIND v(dout1_30) AT=685.025n

.meas tran vdout1_31ck1360 FIND v(dout1_31) AT=685.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_23ck1370 FIND v(dout1_23) AT=690.025n

.meas tran vdout1_24ck1370 FIND v(dout1_24) AT=690.025n

.meas tran vdout1_25ck1370 FIND v(dout1_25) AT=690.025n

.meas tran vdout1_26ck1370 FIND v(dout1_26) AT=690.025n

.meas tran vdout1_27ck1370 FIND v(dout1_27) AT=690.025n

.meas tran vdout1_28ck1370 FIND v(dout1_28) AT=690.025n

.meas tran vdout1_29ck1370 FIND v(dout1_29) AT=690.025n

.meas tran vdout1_30ck1370 FIND v(dout1_30) AT=690.025n

.meas tran vdout1_31ck1370 FIND v(dout1_31) AT=690.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_19ck1380 FIND v(dout1_19) AT=695.025n

.meas tran vdout1_20ck1380 FIND v(dout1_20) AT=695.025n

.meas tran vdout1_21ck1380 FIND v(dout1_21) AT=695.025n

.meas tran vdout1_22ck1380 FIND v(dout1_22) AT=695.025n

.meas tran vdout1_23ck1380 FIND v(dout1_23) AT=695.025n

.meas tran vdout1_24ck1380 FIND v(dout1_24) AT=695.025n

.meas tran vdout1_25ck1380 FIND v(dout1_25) AT=695.025n

.meas tran vdout1_26ck1380 FIND v(dout1_26) AT=695.025n

.meas tran vdout1_27ck1380 FIND v(dout1_27) AT=695.025n

.meas tran vdout1_28ck1380 FIND v(dout1_28) AT=695.025n

.meas tran vdout1_29ck1380 FIND v(dout1_29) AT=695.025n

.meas tran vdout1_30ck1380 FIND v(dout1_30) AT=695.025n

.meas tran vdout1_31ck1380 FIND v(dout1_31) AT=695.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_16ck1390 FIND v(dout1_16) AT=700.025n

.meas tran vdout1_17ck1390 FIND v(dout1_17) AT=700.025n

.meas tran vdout1_18ck1390 FIND v(dout1_18) AT=700.025n

.meas tran vdout1_19ck1390 FIND v(dout1_19) AT=700.025n

.meas tran vdout1_20ck1390 FIND v(dout1_20) AT=700.025n

.meas tran vdout1_21ck1390 FIND v(dout1_21) AT=700.025n

.meas tran vdout1_22ck1390 FIND v(dout1_22) AT=700.025n

.meas tran vdout1_23ck1390 FIND v(dout1_23) AT=700.025n

.meas tran vdout1_24ck1390 FIND v(dout1_24) AT=700.025n

.meas tran vdout1_25ck1390 FIND v(dout1_25) AT=700.025n

.meas tran vdout1_26ck1390 FIND v(dout1_26) AT=700.025n

.meas tran vdout1_27ck1390 FIND v(dout1_27) AT=700.025n

.meas tran vdout1_28ck1390 FIND v(dout1_28) AT=700.025n

.meas tran vdout1_29ck1390 FIND v(dout1_29) AT=700.025n

.meas tran vdout1_30ck1390 FIND v(dout1_30) AT=700.025n

.meas tran vdout1_31ck1390 FIND v(dout1_31) AT=700.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_16ck1480 FIND v(dout1_16) AT=745.025n

.meas tran vdout1_17ck1480 FIND v(dout1_17) AT=745.025n

.meas tran vdout1_18ck1480 FIND v(dout1_18) AT=745.025n

.meas tran vdout1_19ck1480 FIND v(dout1_19) AT=745.025n

.meas tran vdout1_20ck1480 FIND v(dout1_20) AT=745.025n

.meas tran vdout1_21ck1480 FIND v(dout1_21) AT=745.025n

.meas tran vdout1_22ck1480 FIND v(dout1_22) AT=745.025n

.meas tran vdout1_23ck1480 FIND v(dout1_23) AT=745.025n

.meas tran vdout1_24ck1480 FIND v(dout1_24) AT=745.025n

.meas tran vdout1_25ck1480 FIND v(dout1_25) AT=745.025n

.meas tran vdout1_26ck1480 FIND v(dout1_26) AT=745.025n

.meas tran vdout1_27ck1480 FIND v(dout1_27) AT=745.025n

.meas tran vdout1_28ck1480 FIND v(dout1_28) AT=745.025n

.meas tran vdout1_29ck1480 FIND v(dout1_29) AT=745.025n

.meas tran vdout1_30ck1480 FIND v(dout1_30) AT=745.025n

.meas tran vdout1_31ck1480 FIND v(dout1_31) AT=745.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_22ck1490 FIND v(dout1_22) AT=750.025n

.meas tran vdout1_23ck1490 FIND v(dout1_23) AT=750.025n

.meas tran vdout1_24ck1490 FIND v(dout1_24) AT=750.025n

.meas tran vdout1_25ck1490 FIND v(dout1_25) AT=750.025n

.meas tran vdout1_26ck1490 FIND v(dout1_26) AT=750.025n

.meas tran vdout1_27ck1490 FIND v(dout1_27) AT=750.025n

.meas tran vdout1_28ck1490 FIND v(dout1_28) AT=750.025n

.meas tran vdout1_29ck1490 FIND v(dout1_29) AT=750.025n

.meas tran vdout1_30ck1490 FIND v(dout1_30) AT=750.025n

.meas tran vdout1_31ck1490 FIND v(dout1_31) AT=750.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_16ck1500 FIND v(dout1_16) AT=755.025n

.meas tran vdout1_17ck1500 FIND v(dout1_17) AT=755.025n

.meas tran vdout1_18ck1500 FIND v(dout1_18) AT=755.025n

.meas tran vdout1_19ck1500 FIND v(dout1_19) AT=755.025n

.meas tran vdout1_20ck1500 FIND v(dout1_20) AT=755.025n

.meas tran vdout1_21ck1500 FIND v(dout1_21) AT=755.025n

.meas tran vdout1_22ck1500 FIND v(dout1_22) AT=755.025n

.meas tran vdout1_23ck1500 FIND v(dout1_23) AT=755.025n

.meas tran vdout1_24ck1500 FIND v(dout1_24) AT=755.025n

.meas tran vdout1_25ck1500 FIND v(dout1_25) AT=755.025n

.meas tran vdout1_26ck1500 FIND v(dout1_26) AT=755.025n

.meas tran vdout1_27ck1500 FIND v(dout1_27) AT=755.025n

.meas tran vdout1_28ck1500 FIND v(dout1_28) AT=755.025n

.meas tran vdout1_29ck1500 FIND v(dout1_29) AT=755.025n

.meas tran vdout1_30ck1500 FIND v(dout1_30) AT=755.025n

.meas tran vdout1_31ck1500 FIND v(dout1_31) AT=755.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_16ck1520 FIND v(dout1_16) AT=765.025n

.meas tran vdout1_17ck1520 FIND v(dout1_17) AT=765.025n

.meas tran vdout1_18ck1520 FIND v(dout1_18) AT=765.025n

.meas tran vdout1_19ck1520 FIND v(dout1_19) AT=765.025n

.meas tran vdout1_20ck1520 FIND v(dout1_20) AT=765.025n

.meas tran vdout1_21ck1520 FIND v(dout1_21) AT=765.025n

.meas tran vdout1_22ck1520 FIND v(dout1_22) AT=765.025n

.meas tran vdout1_23ck1520 FIND v(dout1_23) AT=765.025n

.meas tran vdout1_24ck1520 FIND v(dout1_24) AT=765.025n

.meas tran vdout1_25ck1520 FIND v(dout1_25) AT=765.025n

.meas tran vdout1_26ck1520 FIND v(dout1_26) AT=765.025n

.meas tran vdout1_27ck1520 FIND v(dout1_27) AT=765.025n

.meas tran vdout1_28ck1520 FIND v(dout1_28) AT=765.025n

.meas tran vdout1_29ck1520 FIND v(dout1_29) AT=765.025n

.meas tran vdout1_30ck1520 FIND v(dout1_30) AT=765.025n

.meas tran vdout1_31ck1520 FIND v(dout1_31) AT=765.025n

.meas tran vdout1_0ck1530 FIND v(dout1_0) AT=770.025n

.meas tran vdout1_1ck1530 FIND v(dout1_1) AT=770.025n

.meas tran vdout1_2ck1530 FIND v(dout1_2) AT=770.025n

.meas tran vdout1_3ck1530 FIND v(dout1_3) AT=770.025n

.meas tran vdout1_4ck1530 FIND v(dout1_4) AT=770.025n

.meas tran vdout1_5ck1530 FIND v(dout1_5) AT=770.025n

.meas tran vdout1_6ck1530 FIND v(dout1_6) AT=770.025n

.meas tran vdout1_7ck1530 FIND v(dout1_7) AT=770.025n

.meas tran vdout1_8ck1530 FIND v(dout1_8) AT=770.025n

.meas tran vdout1_9ck1530 FIND v(dout1_9) AT=770.025n

.meas tran vdout1_10ck1530 FIND v(dout1_10) AT=770.025n

.meas tran vdout1_11ck1530 FIND v(dout1_11) AT=770.025n

.meas tran vdout1_12ck1530 FIND v(dout1_12) AT=770.025n

.meas tran vdout1_13ck1530 FIND v(dout1_13) AT=770.025n

.meas tran vdout1_14ck1530 FIND v(dout1_14) AT=770.025n

.meas tran vdout1_15ck1530 FIND v(dout1_15) AT=770.025n

.meas tran vdout1_16ck1530 FIND v(dout1_16) AT=770.025n

.meas tran vdout1_17ck1530 FIND v(dout1_17) AT=770.025n

.meas tran vdout1_18ck1530 FIND v(dout1_18) AT=770.025n

.meas tran vdout1_19ck1530 FIND v(dout1_19) AT=770.025n

.meas tran vdout1_20ck1530 FIND v(dout1_20) AT=770.025n

.meas tran vdout1_21ck1530 FIND v(dout1_21) AT=770.025n

.meas tran vdout1_22ck1530 FIND v(dout1_22) AT=770.025n

.meas tran vdout1_23ck1530 FIND v(dout1_23) AT=770.025n

.meas tran vdout1_24ck1530 FIND v(dout1_24) AT=770.025n

.meas tran vdout1_25ck1530 FIND v(dout1_25) AT=770.025n

.meas tran vdout1_26ck1530 FIND v(dout1_26) AT=770.025n

.meas tran vdout1_27ck1530 FIND v(dout1_27) AT=770.025n

.meas tran vdout1_28ck1530 FIND v(dout1_28) AT=770.025n

.meas tran vdout1_29ck1530 FIND v(dout1_29) AT=770.025n

.meas tran vdout1_30ck1530 FIND v(dout1_30) AT=770.025n

.meas tran vdout1_31ck1530 FIND v(dout1_31) AT=770.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_23ck1540 FIND v(dout1_23) AT=775.025n

.meas tran vdout1_24ck1540 FIND v(dout1_24) AT=775.025n

.meas tran vdout1_25ck1540 FIND v(dout1_25) AT=775.025n

.meas tran vdout1_26ck1540 FIND v(dout1_26) AT=775.025n

.meas tran vdout1_27ck1540 FIND v(dout1_27) AT=775.025n

.meas tran vdout1_28ck1540 FIND v(dout1_28) AT=775.025n

.meas tran vdout1_29ck1540 FIND v(dout1_29) AT=775.025n

.meas tran vdout1_30ck1540 FIND v(dout1_30) AT=775.025n

.meas tran vdout1_31ck1540 FIND v(dout1_31) AT=775.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_16ck1560 FIND v(dout1_16) AT=785.025n

.meas tran vdout1_17ck1560 FIND v(dout1_17) AT=785.025n

.meas tran vdout1_18ck1560 FIND v(dout1_18) AT=785.025n

.meas tran vdout1_19ck1560 FIND v(dout1_19) AT=785.025n

.meas tran vdout1_20ck1560 FIND v(dout1_20) AT=785.025n

.meas tran vdout1_21ck1560 FIND v(dout1_21) AT=785.025n

.meas tran vdout1_22ck1560 FIND v(dout1_22) AT=785.025n

.meas tran vdout1_23ck1560 FIND v(dout1_23) AT=785.025n

.meas tran vdout1_24ck1560 FIND v(dout1_24) AT=785.025n

.meas tran vdout1_25ck1560 FIND v(dout1_25) AT=785.025n

.meas tran vdout1_26ck1560 FIND v(dout1_26) AT=785.025n

.meas tran vdout1_27ck1560 FIND v(dout1_27) AT=785.025n

.meas tran vdout1_28ck1560 FIND v(dout1_28) AT=785.025n

.meas tran vdout1_29ck1560 FIND v(dout1_29) AT=785.025n

.meas tran vdout1_30ck1560 FIND v(dout1_30) AT=785.025n

.meas tran vdout1_31ck1560 FIND v(dout1_31) AT=785.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_17ck1570 FIND v(dout1_17) AT=790.025n

.meas tran vdout1_18ck1570 FIND v(dout1_18) AT=790.025n

.meas tran vdout1_19ck1570 FIND v(dout1_19) AT=790.025n

.meas tran vdout1_20ck1570 FIND v(dout1_20) AT=790.025n

.meas tran vdout1_21ck1570 FIND v(dout1_21) AT=790.025n

.meas tran vdout1_22ck1570 FIND v(dout1_22) AT=790.025n

.meas tran vdout1_23ck1570 FIND v(dout1_23) AT=790.025n

.meas tran vdout1_24ck1570 FIND v(dout1_24) AT=790.025n

.meas tran vdout1_25ck1570 FIND v(dout1_25) AT=790.025n

.meas tran vdout1_26ck1570 FIND v(dout1_26) AT=790.025n

.meas tran vdout1_27ck1570 FIND v(dout1_27) AT=790.025n

.meas tran vdout1_28ck1570 FIND v(dout1_28) AT=790.025n

.meas tran vdout1_29ck1570 FIND v(dout1_29) AT=790.025n

.meas tran vdout1_30ck1570 FIND v(dout1_30) AT=790.025n

.meas tran vdout1_31ck1570 FIND v(dout1_31) AT=790.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_19ck1590 FIND v(dout1_19) AT=800.025n

.meas tran vdout1_20ck1590 FIND v(dout1_20) AT=800.025n

.meas tran vdout1_21ck1590 FIND v(dout1_21) AT=800.025n

.meas tran vdout1_22ck1590 FIND v(dout1_22) AT=800.025n

.meas tran vdout1_23ck1590 FIND v(dout1_23) AT=800.025n

.meas tran vdout1_24ck1590 FIND v(dout1_24) AT=800.025n

.meas tran vdout1_25ck1590 FIND v(dout1_25) AT=800.025n

.meas tran vdout1_26ck1590 FIND v(dout1_26) AT=800.025n

.meas tran vdout1_27ck1590 FIND v(dout1_27) AT=800.025n

.meas tran vdout1_28ck1590 FIND v(dout1_28) AT=800.025n

.meas tran vdout1_29ck1590 FIND v(dout1_29) AT=800.025n

.meas tran vdout1_30ck1590 FIND v(dout1_30) AT=800.025n

.meas tran vdout1_31ck1590 FIND v(dout1_31) AT=800.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_19ck1600 FIND v(dout1_19) AT=805.025n

.meas tran vdout1_20ck1600 FIND v(dout1_20) AT=805.025n

.meas tran vdout1_21ck1600 FIND v(dout1_21) AT=805.025n

.meas tran vdout1_22ck1600 FIND v(dout1_22) AT=805.025n

.meas tran vdout1_23ck1600 FIND v(dout1_23) AT=805.025n

.meas tran vdout1_24ck1600 FIND v(dout1_24) AT=805.025n

.meas tran vdout1_25ck1600 FIND v(dout1_25) AT=805.025n

.meas tran vdout1_26ck1600 FIND v(dout1_26) AT=805.025n

.meas tran vdout1_27ck1600 FIND v(dout1_27) AT=805.025n

.meas tran vdout1_28ck1600 FIND v(dout1_28) AT=805.025n

.meas tran vdout1_29ck1600 FIND v(dout1_29) AT=805.025n

.meas tran vdout1_30ck1600 FIND v(dout1_30) AT=805.025n

.meas tran vdout1_31ck1600 FIND v(dout1_31) AT=805.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_22ck1610 FIND v(dout1_22) AT=810.025n

.meas tran vdout1_23ck1610 FIND v(dout1_23) AT=810.025n

.meas tran vdout1_24ck1610 FIND v(dout1_24) AT=810.025n

.meas tran vdout1_25ck1610 FIND v(dout1_25) AT=810.025n

.meas tran vdout1_26ck1610 FIND v(dout1_26) AT=810.025n

.meas tran vdout1_27ck1610 FIND v(dout1_27) AT=810.025n

.meas tran vdout1_28ck1610 FIND v(dout1_28) AT=810.025n

.meas tran vdout1_29ck1610 FIND v(dout1_29) AT=810.025n

.meas tran vdout1_30ck1610 FIND v(dout1_30) AT=810.025n

.meas tran vdout1_31ck1610 FIND v(dout1_31) AT=810.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_16ck1620 FIND v(dout1_16) AT=815.025n

.meas tran vdout1_17ck1620 FIND v(dout1_17) AT=815.025n

.meas tran vdout1_18ck1620 FIND v(dout1_18) AT=815.025n

.meas tran vdout1_19ck1620 FIND v(dout1_19) AT=815.025n

.meas tran vdout1_20ck1620 FIND v(dout1_20) AT=815.025n

.meas tran vdout1_21ck1620 FIND v(dout1_21) AT=815.025n

.meas tran vdout1_22ck1620 FIND v(dout1_22) AT=815.025n

.meas tran vdout1_23ck1620 FIND v(dout1_23) AT=815.025n

.meas tran vdout1_24ck1620 FIND v(dout1_24) AT=815.025n

.meas tran vdout1_25ck1620 FIND v(dout1_25) AT=815.025n

.meas tran vdout1_26ck1620 FIND v(dout1_26) AT=815.025n

.meas tran vdout1_27ck1620 FIND v(dout1_27) AT=815.025n

.meas tran vdout1_28ck1620 FIND v(dout1_28) AT=815.025n

.meas tran vdout1_29ck1620 FIND v(dout1_29) AT=815.025n

.meas tran vdout1_30ck1620 FIND v(dout1_30) AT=815.025n

.meas tran vdout1_31ck1620 FIND v(dout1_31) AT=815.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_19ck1700 FIND v(dout1_19) AT=855.025n

.meas tran vdout1_20ck1700 FIND v(dout1_20) AT=855.025n

.meas tran vdout1_21ck1700 FIND v(dout1_21) AT=855.025n

.meas tran vdout1_22ck1700 FIND v(dout1_22) AT=855.025n

.meas tran vdout1_23ck1700 FIND v(dout1_23) AT=855.025n

.meas tran vdout1_24ck1700 FIND v(dout1_24) AT=855.025n

.meas tran vdout1_25ck1700 FIND v(dout1_25) AT=855.025n

.meas tran vdout1_26ck1700 FIND v(dout1_26) AT=855.025n

.meas tran vdout1_27ck1700 FIND v(dout1_27) AT=855.025n

.meas tran vdout1_28ck1700 FIND v(dout1_28) AT=855.025n

.meas tran vdout1_29ck1700 FIND v(dout1_29) AT=855.025n

.meas tran vdout1_30ck1700 FIND v(dout1_30) AT=855.025n

.meas tran vdout1_31ck1700 FIND v(dout1_31) AT=855.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_16ck1720 FIND v(dout1_16) AT=865.025n

.meas tran vdout1_17ck1720 FIND v(dout1_17) AT=865.025n

.meas tran vdout1_18ck1720 FIND v(dout1_18) AT=865.025n

.meas tran vdout1_19ck1720 FIND v(dout1_19) AT=865.025n

.meas tran vdout1_20ck1720 FIND v(dout1_20) AT=865.025n

.meas tran vdout1_21ck1720 FIND v(dout1_21) AT=865.025n

.meas tran vdout1_22ck1720 FIND v(dout1_22) AT=865.025n

.meas tran vdout1_23ck1720 FIND v(dout1_23) AT=865.025n

.meas tran vdout1_24ck1720 FIND v(dout1_24) AT=865.025n

.meas tran vdout1_25ck1720 FIND v(dout1_25) AT=865.025n

.meas tran vdout1_26ck1720 FIND v(dout1_26) AT=865.025n

.meas tran vdout1_27ck1720 FIND v(dout1_27) AT=865.025n

.meas tran vdout1_28ck1720 FIND v(dout1_28) AT=865.025n

.meas tran vdout1_29ck1720 FIND v(dout1_29) AT=865.025n

.meas tran vdout1_30ck1720 FIND v(dout1_30) AT=865.025n

.meas tran vdout1_31ck1720 FIND v(dout1_31) AT=865.025n

.meas tran vdout1_0ck1770 FIND v(dout1_0) AT=890.025n

.meas tran vdout1_1ck1770 FIND v(dout1_1) AT=890.025n

.meas tran vdout1_2ck1770 FIND v(dout1_2) AT=890.025n

.meas tran vdout1_3ck1770 FIND v(dout1_3) AT=890.025n

.meas tran vdout1_4ck1770 FIND v(dout1_4) AT=890.025n

.meas tran vdout1_5ck1770 FIND v(dout1_5) AT=890.025n

.meas tran vdout1_6ck1770 FIND v(dout1_6) AT=890.025n

.meas tran vdout1_7ck1770 FIND v(dout1_7) AT=890.025n

.meas tran vdout1_8ck1770 FIND v(dout1_8) AT=890.025n

.meas tran vdout1_9ck1770 FIND v(dout1_9) AT=890.025n

.meas tran vdout1_10ck1770 FIND v(dout1_10) AT=890.025n

.meas tran vdout1_11ck1770 FIND v(dout1_11) AT=890.025n

.meas tran vdout1_12ck1770 FIND v(dout1_12) AT=890.025n

.meas tran vdout1_13ck1770 FIND v(dout1_13) AT=890.025n

.meas tran vdout1_14ck1770 FIND v(dout1_14) AT=890.025n

.meas tran vdout1_15ck1770 FIND v(dout1_15) AT=890.025n

.meas tran vdout1_16ck1770 FIND v(dout1_16) AT=890.025n

.meas tran vdout1_17ck1770 FIND v(dout1_17) AT=890.025n

.meas tran vdout1_18ck1770 FIND v(dout1_18) AT=890.025n

.meas tran vdout1_19ck1770 FIND v(dout1_19) AT=890.025n

.meas tran vdout1_20ck1770 FIND v(dout1_20) AT=890.025n

.meas tran vdout1_21ck1770 FIND v(dout1_21) AT=890.025n

.meas tran vdout1_22ck1770 FIND v(dout1_22) AT=890.025n

.meas tran vdout1_23ck1770 FIND v(dout1_23) AT=890.025n

.meas tran vdout1_24ck1770 FIND v(dout1_24) AT=890.025n

.meas tran vdout1_25ck1770 FIND v(dout1_25) AT=890.025n

.meas tran vdout1_26ck1770 FIND v(dout1_26) AT=890.025n

.meas tran vdout1_27ck1770 FIND v(dout1_27) AT=890.025n

.meas tran vdout1_28ck1770 FIND v(dout1_28) AT=890.025n

.meas tran vdout1_29ck1770 FIND v(dout1_29) AT=890.025n

.meas tran vdout1_30ck1770 FIND v(dout1_30) AT=890.025n

.meas tran vdout1_31ck1770 FIND v(dout1_31) AT=890.025n

.meas tran vdout1_0ck1790 FIND v(dout1_0) AT=900.025n

.meas tran vdout1_1ck1790 FIND v(dout1_1) AT=900.025n

.meas tran vdout1_2ck1790 FIND v(dout1_2) AT=900.025n

.meas tran vdout1_3ck1790 FIND v(dout1_3) AT=900.025n

.meas tran vdout1_4ck1790 FIND v(dout1_4) AT=900.025n

.meas tran vdout1_5ck1790 FIND v(dout1_5) AT=900.025n

.meas tran vdout1_6ck1790 FIND v(dout1_6) AT=900.025n

.meas tran vdout1_7ck1790 FIND v(dout1_7) AT=900.025n

.meas tran vdout1_8ck1790 FIND v(dout1_8) AT=900.025n

.meas tran vdout1_9ck1790 FIND v(dout1_9) AT=900.025n

.meas tran vdout1_10ck1790 FIND v(dout1_10) AT=900.025n

.meas tran vdout1_11ck1790 FIND v(dout1_11) AT=900.025n

.meas tran vdout1_12ck1790 FIND v(dout1_12) AT=900.025n

.meas tran vdout1_13ck1790 FIND v(dout1_13) AT=900.025n

.meas tran vdout1_14ck1790 FIND v(dout1_14) AT=900.025n

.meas tran vdout1_15ck1790 FIND v(dout1_15) AT=900.025n

.meas tran vdout1_16ck1790 FIND v(dout1_16) AT=900.025n

.meas tran vdout1_17ck1790 FIND v(dout1_17) AT=900.025n

.meas tran vdout1_18ck1790 FIND v(dout1_18) AT=900.025n

.meas tran vdout1_19ck1790 FIND v(dout1_19) AT=900.025n

.meas tran vdout1_20ck1790 FIND v(dout1_20) AT=900.025n

.meas tran vdout1_21ck1790 FIND v(dout1_21) AT=900.025n

.meas tran vdout1_22ck1790 FIND v(dout1_22) AT=900.025n

.meas tran vdout1_23ck1790 FIND v(dout1_23) AT=900.025n

.meas tran vdout1_24ck1790 FIND v(dout1_24) AT=900.025n

.meas tran vdout1_25ck1790 FIND v(dout1_25) AT=900.025n

.meas tran vdout1_26ck1790 FIND v(dout1_26) AT=900.025n

.meas tran vdout1_27ck1790 FIND v(dout1_27) AT=900.025n

.meas tran vdout1_28ck1790 FIND v(dout1_28) AT=900.025n

.meas tran vdout1_29ck1790 FIND v(dout1_29) AT=900.025n

.meas tran vdout1_30ck1790 FIND v(dout1_30) AT=900.025n

.meas tran vdout1_31ck1790 FIND v(dout1_31) AT=900.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_8ck1900 FIND v(dout1_8) AT=955.025n

.meas tran vdout1_9ck1900 FIND v(dout1_9) AT=955.025n

.meas tran vdout1_10ck1900 FIND v(dout1_10) AT=955.025n

.meas tran vdout1_11ck1900 FIND v(dout1_11) AT=955.025n

.meas tran vdout1_12ck1900 FIND v(dout1_12) AT=955.025n

.meas tran vdout1_13ck1900 FIND v(dout1_13) AT=955.025n

.meas tran vdout1_14ck1900 FIND v(dout1_14) AT=955.025n

.meas tran vdout1_15ck1900 FIND v(dout1_15) AT=955.025n

.meas tran vdout1_16ck1900 FIND v(dout1_16) AT=955.025n

.meas tran vdout1_17ck1900 FIND v(dout1_17) AT=955.025n

.meas tran vdout1_18ck1900 FIND v(dout1_18) AT=955.025n

.meas tran vdout1_19ck1900 FIND v(dout1_19) AT=955.025n

.meas tran vdout1_20ck1900 FIND v(dout1_20) AT=955.025n

.meas tran vdout1_21ck1900 FIND v(dout1_21) AT=955.025n

.meas tran vdout1_22ck1900 FIND v(dout1_22) AT=955.025n

.meas tran vdout1_23ck1900 FIND v(dout1_23) AT=955.025n

.meas tran vdout1_24ck1900 FIND v(dout1_24) AT=955.025n

.meas tran vdout1_25ck1900 FIND v(dout1_25) AT=955.025n

.meas tran vdout1_26ck1900 FIND v(dout1_26) AT=955.025n

.meas tran vdout1_27ck1900 FIND v(dout1_27) AT=955.025n

.meas tran vdout1_28ck1900 FIND v(dout1_28) AT=955.025n

.meas tran vdout1_29ck1900 FIND v(dout1_29) AT=955.025n

.meas tran vdout1_30ck1900 FIND v(dout1_30) AT=955.025n

.meas tran vdout1_31ck1900 FIND v(dout1_31) AT=955.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_23ck1910 FIND v(dout1_23) AT=960.025n

.meas tran vdout1_24ck1910 FIND v(dout1_24) AT=960.025n

.meas tran vdout1_25ck1910 FIND v(dout1_25) AT=960.025n

.meas tran vdout1_26ck1910 FIND v(dout1_26) AT=960.025n

.meas tran vdout1_27ck1910 FIND v(dout1_27) AT=960.025n

.meas tran vdout1_28ck1910 FIND v(dout1_28) AT=960.025n

.meas tran vdout1_29ck1910 FIND v(dout1_29) AT=960.025n

.meas tran vdout1_30ck1910 FIND v(dout1_30) AT=960.025n

.meas tran vdout1_31ck1910 FIND v(dout1_31) AT=960.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_16ck1980 FIND v(dout1_16) AT=995.025n

.meas tran vdout1_17ck1980 FIND v(dout1_17) AT=995.025n

.meas tran vdout1_18ck1980 FIND v(dout1_18) AT=995.025n

.meas tran vdout1_19ck1980 FIND v(dout1_19) AT=995.025n

.meas tran vdout1_20ck1980 FIND v(dout1_20) AT=995.025n

.meas tran vdout1_21ck1980 FIND v(dout1_21) AT=995.025n

.meas tran vdout1_22ck1980 FIND v(dout1_22) AT=995.025n

.meas tran vdout1_23ck1980 FIND v(dout1_23) AT=995.025n

.meas tran vdout1_24ck1980 FIND v(dout1_24) AT=995.025n

.meas tran vdout1_25ck1980 FIND v(dout1_25) AT=995.025n

.meas tran vdout1_26ck1980 FIND v(dout1_26) AT=995.025n

.meas tran vdout1_27ck1980 FIND v(dout1_27) AT=995.025n

.meas tran vdout1_28ck1980 FIND v(dout1_28) AT=995.025n

.meas tran vdout1_29ck1980 FIND v(dout1_29) AT=995.025n

.meas tran vdout1_30ck1980 FIND v(dout1_30) AT=995.025n

.meas tran vdout1_31ck1980 FIND v(dout1_31) AT=995.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n

.meas tran vdout1_16ck2030 FIND v(dout1_16) AT=1020.025n

.meas tran vdout1_17ck2030 FIND v(dout1_17) AT=1020.025n

.meas tran vdout1_18ck2030 FIND v(dout1_18) AT=1020.025n

.meas tran vdout1_19ck2030 FIND v(dout1_19) AT=1020.025n

.meas tran vdout1_20ck2030 FIND v(dout1_20) AT=1020.025n

.meas tran vdout1_21ck2030 FIND v(dout1_21) AT=1020.025n

.meas tran vdout1_22ck2030 FIND v(dout1_22) AT=1020.025n

.meas tran vdout1_23ck2030 FIND v(dout1_23) AT=1020.025n

.meas tran vdout1_24ck2030 FIND v(dout1_24) AT=1020.025n

.meas tran vdout1_25ck2030 FIND v(dout1_25) AT=1020.025n

.meas tran vdout1_26ck2030 FIND v(dout1_26) AT=1020.025n

.meas tran vdout1_27ck2030 FIND v(dout1_27) AT=1020.025n

.meas tran vdout1_28ck2030 FIND v(dout1_28) AT=1020.025n

.meas tran vdout1_29ck2030 FIND v(dout1_29) AT=1020.025n

.meas tran vdout1_30ck2030 FIND v(dout1_30) AT=1020.025n

.meas tran vdout1_31ck2030 FIND v(dout1_31) AT=1020.025n
